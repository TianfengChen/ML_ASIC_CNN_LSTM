$ Spice netlist generated by v2lvs
$ v2021.3_15.9    Tue Jul 6 13:44:20 PDT 2021
.INCLUDE "/afs/umich.edu/class/eecs627/ibm13/artisan/current/aci/sc-x/lvs_netlist/ibm13.cdl"
.INCLUDE "/afs/umich.edu/class/eecs627/w23/lab_resource/lab3/reset_driver.cdl"
*.BUSDELIMITER <

.SUBCKT PE_POOL_top clk reset pe_in_pk_PE_state__2_ pe_in_pk_PE_state__1_
+ pe_in_pk_PE_state__0_ pe_in_pk_A__3__7_ pe_in_pk_A__3__6_ pe_in_pk_A__3__5_
+ pe_in_pk_A__3__4_ pe_in_pk_A__3__3_ pe_in_pk_A__3__2_ pe_in_pk_A__3__1_
+ pe_in_pk_A__3__0_ pe_in_pk_A__2__7_ pe_in_pk_A__2__6_ pe_in_pk_A__2__5_
+ pe_in_pk_A__2__4_ pe_in_pk_A__2__3_ pe_in_pk_A__2__2_ pe_in_pk_A__2__1_
+ pe_in_pk_A__2__0_ pe_in_pk_A__1__7_ pe_in_pk_A__1__6_ pe_in_pk_A__1__5_
+ pe_in_pk_A__1__4_ pe_in_pk_A__1__3_ pe_in_pk_A__1__2_ pe_in_pk_A__1__1_
+ pe_in_pk_A__1__0_ pe_in_pk_A__0__7_ pe_in_pk_A__0__6_ pe_in_pk_A__0__5_
+ pe_in_pk_A__0__4_ pe_in_pk_A__0__3_ pe_in_pk_A__0__2_ pe_in_pk_A__0__1_
+ pe_in_pk_A__0__0_ pe_in_pk_wrb_data__7_ pe_in_pk_wrb_data__6_
+ pe_in_pk_wrb_data__5_ pe_in_pk_wrb_data__4_ pe_in_pk_wrb_data__3_
+ pe_in_pk_wrb_data__2_ pe_in_pk_wrb_data__1_ pe_in_pk_wrb_data__0_
+ pe_in_pk_wrb_addr__3_ pe_in_pk_wrb_addr__2_ pe_in_pk_wrb_addr__1_
+ pe_in_pk_wrb_addr__0_ pe_in_pk_wrb__3_ pe_in_pk_wrb__2_ pe_in_pk_wrb__1_
+ pe_in_pk_wrb__0_ pe_in_pk_rdb_addr__3_ pe_in_pk_rdb_addr__2_
+ pe_in_pk_rdb_addr__1_ pe_in_pk_rdb_addr__0_ pk_out_PE_state__2_
+ pk_out_PE_state__1_ pk_out_PE_state__0_ pk_out_data__7_ pk_out_data__6_
+ pk_out_data__5_ pk_out_data__4_ pk_out_data__3_ pk_out_data__2_
+ pk_out_data__1_ pk_out_data__0_
*.CONNECT pk_out_data__7_ VSS
XPOSTROUTEFE_PSC238_n937 BUFX3TR $PINS A=n937 Y=FE_PSN238_n937
XPOSTROUTEFE_PSBC236_n915 BUFX8TR $PINS A=n915 Y=FE_PSBN144_n915
XPOSTROUTEFE_PSC237_n900 CLKBUFX2TR $PINS A=n900 Y=FE_PSN237_n900
XPOSTROUTEFE_PSC236_n925 CLKBUFX2TR $PINS A=n925 Y=FE_PSN236_n925
XPOSTROUTEFE_PSC235_n880 BUFX3TR $PINS A=n880 Y=FE_PSN235_n880
XPLACEDFE_OCPC235_n879 BUFX8TR $PINS A=n879 Y=FE_OCPN143_n879
XPLACEDFE_OCPC234_n157 BUFX3TR $PINS A=n157 Y=FE_OCPN142_n157
XPLACEDFE_OCPC233_n162 BUFX8TR $PINS A=n162 Y=FE_OCPN141_n162
XPLACEDFE_OFC232_n1076 BUFX6TR $PINS A=FE_OFN11_n1076 Y=FE_OFN51_n1076
XPLACEDFE_OFC231_n1076 BUFX6TR $PINS A=n1076 Y=FE_OFN11_n1076
XPLACEDFE_OFC229_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN140_n887
XPLACEDFE_OFC228_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN139_n887
XPLACEDFE_OFC227_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN138_n887
XPLACEDFE_OFC226_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN137_n887
XPLACEDFE_OFC225_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN136_n887
XPLACEDFE_OFC224_n887 CLKINVX2TR $PINS A=n1034 Y=FE_OFN135_n887
XPLACEDFE_OFC223_n887 INVX2TR $PINS A=n887 Y=n1034
XPLACEDFE_OFC222_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN134_n943
XPLACEDFE_OFC221_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN133_n943
XPLACEDFE_OFC220_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN132_n943
XPLACEDFE_OFC219_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN131_n943
XPLACEDFE_OFC218_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN130_n943
XPLACEDFE_OFC217_n943 CLKINVX2TR $PINS A=n982 Y=FE_OFN129_n943
XPLACEDFE_OFC216_n943 INVX2TR $PINS A=n943 Y=n982
XPLACEDFE_OFC215_n884 INVX2TR $PINS A=n884 Y=n1019
XPLACEDFE_OFC214_n1100 CLKINVX2TR $PINS A=FE_OFN24_n1100 Y=FE_OFN128_n1100
XPLACEDFE_OFC213_n1100 CLKINVX4TR $PINS A=FE_OFN24_n1100 Y=FE_OFN105_n1100
XPLACEDFE_OFC212_n1100 INVX2TR $PINS A=FE_OFN23_n1100 Y=FE_OFN24_n1100
XPLACEDFE_OFC211_n1100 BUFX4TR $PINS A=n1100 Y=FE_OFN23_n1100
XPLACEDFE_OFC210_n939 CLKBUFX2TR $PINS A=n939 Y=FE_OFN127_n939
XPLACEDFE_OFC209_n939 CLKINVX2TR $PINS A=n939 Y=n984
XPLACEDFE_OFC208_n921 CLKINVX2TR $PINS A=FE_OFN81_n921 Y=FE_OFN126_n921
XPLACEDFE_OFC207_n921 CLKINVX2TR $PINS A=FE_OFN81_n921 Y=FE_OFN125_n921
XPLACEDFE_OFC206_n921 CLKINVX2TR $PINS A=FE_OFN81_n921 Y=FE_OFN124_n921
XPLACEDFE_OFC205_n921 CLKINVX2TR $PINS A=FE_OFN81_n921 Y=FE_OFN123_n921
XPLACEDFE_OFC204_n921 CLKINVX2TR $PINS A=FE_OFN81_n921 Y=FE_OFN122_n921
XPLACEDFE_OFC203_n921 INVX2TR $PINS A=n921 Y=FE_OFN81_n921
XPLACEDFE_OFC202_n1096 CLKBUFX2TR $PINS A=FE_OFN14_n1096 Y=FE_OFN79_n1096
XPLACEDFE_OFC201_n1096 CLKINVX6TR $PINS A=FE_OFN15_n1096 Y=FE_OFN14_n1096
XPLACEDFE_OFC200_n1096 CLKINVX2TR $PINS A=n1096 Y=FE_OFN15_n1096
XPLACEDFE_OFC199_n927 INVX2TR $PINS A=n927 Y=n1011
XPLACEDFE_OFC198_n937 INVX4TR $PINS A=FE_PSN238_n937 Y=n980
XPLACEDFE_OFC197_n883 INVX2TR $PINS A=n883 Y=n1025
XPLACEDFE_OFC196_n917 INVX2TR $PINS A=n1000 Y=FE_OFN121_n917
XPLACEDFE_OFC195_n917 INVX2TR $PINS A=n917 Y=n1000
XPLACEDFE_OFC194_reset BUFX3TR $PINS A=FE_OFN27_FE_DBTN1_reset Y=FE_OFN116_n
XPLACEDFE_OFC193_reset BUFX3TR $PINS A=FE_OFN27_FE_DBTN1_reset
+ Y=FE_OFN32_FE_DBTN1_reset
XPLACEDFE_OFC192_reset CLKINVX2TR $PINS A=FE_OFN113_reset Y=FE_OFN115_n
XPLACEDFE_OFC191_reset CLKINVX2TR $PINS A=FE_OFN113_reset
+ Y=FE_OFN31_FE_DBTN1_reset
XPLACEDFE_OFC190_reset INVX2TR $PINS A=FE_OFN113_reset
+ Y=FE_OFN27_FE_DBTN1_reset
XPLACEDFE_OFC189_reset BUFX4TR $PINS A=FE_OFN112_reset Y=FE_OFN8_reset
XPLACEDFE_OFC188_reset CLKINVX6TR $PINS A=FE_OFN1_reset Y=FE_OFN113_reset
XPLACEDFE_OFC187_reset CLKINVX2TR $PINS A=FE_OFN1_reset Y=FE_OFN9_reset
XPLACEDFE_OFC186_reset CLKINVX4TR $PINS A=FE_OFN1_reset Y=FE_OFN112_reset
XPLACEDFE_OFC185_reset CLKINVX6TR $PINS A=reset Y=FE_OFN1_reset
XCTS_ccl_a_inv_00010 CLKINVX20TR $PINS A=CTS_10 Y=CTS_9
XCTS_ccl_a_inv_00009 CLKINVX20TR $PINS A=CTS_10 Y=CTS_8
XCTS_ccl_a_inv_00006 CLKINVX20TR $PINS A=CTS_10 Y=CTS_7
XCTS_ccl_a_inv_00003 CLKINVX20TR $PINS A=CTS_10 Y=CTS_12
XCTS_ccl_a_inv_00002 CLKINVX20TR $PINS A=CTS_10 Y=CTS_11
XCTS_ccl_a_inv_00012 CLKINVX20TR $PINS A=CTS_13 Y=CTS_10
XCTS_ccl_a_inv_00008 CLKINVX20TR $PINS A=CTS_4 Y=CTS_3
XCTS_ccl_a_inv_00007 CLKINVX20TR $PINS A=CTS_4 Y=CTS_2
XCTS_ccl_a_inv_00005 CLKINVX20TR $PINS A=CTS_4 Y=CTS_1
XCTS_ccl_a_inv_00004 CLKINVX20TR $PINS A=CTS_4 Y=CTS_6
XCTS_ccl_a_inv_00001 CLKINVX20TR $PINS A=CTS_4 Y=CTS_5
XCTS_ccl_a_inv_00011 CLKINVX20TR $PINS A=CTS_13 Y=CTS_4
XCTS_ccl_a_inv_00013 CLKINVX20TR $PINS A=CTS_14 Y=CTS_13
XCTS_ccl_a_inv_00014 CLKINVX8TR $PINS A=clk Y=CTS_14
XPLACEDFE_OFC182_reset CLKINVX2TR $PINS A=FE_OFN117_n Y=FE_OFN118_n
XPLACEDFE_OFC181_reset INVX2TR $PINS A=FE_OFN116_n Y=FE_OFN117_n
XPLACEDFE_OFC177_reset CLKINVX2TR $PINS A=FE_OFN113_reset
+ Y=FE_OFN29_FE_DBTN1_reset
XPLACEDFE_OFC174_reset CLKINVX2TR $PINS A=FE_OFN113_reset Y=FE_DBTN1_reset
XPLACEDFE_OFC172_reset CLKINVX2TR $PINS A=FE_OFN1_reset Y=FE_OFN114_reset
XPLACEDFE_OFC169_reset CLKINVX2TR $PINS A=FE_OFN1_reset Y=FE_OFN6_reset
XPLACEDFE_OFC167_reset CLKINVX2TR $PINS A=FE_OFN1_reset Y=FE_OFN3_reset
XPLACEDFE_OFC166_reset CLKINVX2TR $PINS A=FE_OFN1_reset Y=FE_OFN2_reset
XPLACEDFE_OFC164_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN111_n909
XPLACEDFE_OFC163_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN110_n909
XPLACEDFE_OFC162_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN109_n909
XPLACEDFE_OFC161_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN108_n909
XPLACEDFE_OFC160_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN107_n909
XPLACEDFE_OFC159_n909 CLKINVX2TR $PINS A=n986 Y=FE_OFN106_n909
XPLACEDFE_OFC158_n909 CLKINVX2TR $PINS A=n909 Y=n986
XPLACEDFE_OFC154_n967 BUFX3TR $PINS A=FE_OFN43_n967 Y=FE_OFN104_n967
XPLACEDFE_OFC153_n967 BUFX4TR $PINS A=n967 Y=FE_OFN43_n967
XPLACEDFE_OFC151_n971 BUFX3TR $PINS A=FE_OFN46_n971 Y=FE_OFN103_n971
XPLACEDFE_OFC150_n971 BUFX3TR $PINS A=n971 Y=FE_OFN46_n971
XPLACEDFE_OFC148_n913 CLKINVX2TR $PINS A=n994 Y=FE_OFN102_n913
XPLACEDFE_OFC147_n913 CLKINVX2TR $PINS A=n994 Y=FE_OFN101_n913
XPLACEDFE_OFC146_n913 CLKINVX2TR $PINS A=n994 Y=FE_OFN100_n913
XPLACEDFE_OFC145_n913 CLKINVX2TR $PINS A=n994 Y=FE_OFN99_n913
XPLACEDFE_OFC144_n913 CLKINVX2TR $PINS A=n994 Y=FE_OFN98_n913
XPLACEDFE_OFC143_n913 CLKINVX2TR $PINS A=n913 Y=n994
XPLACEDFE_OFC142_n881 BUFX3TR $PINS A=FE_OFN34_n881 Y=FE_OFN97_n881
XPLACEDFE_OFC141_n881 BUFX3TR $PINS A=FE_OFN33_n881 Y=FE_OFN34_n881
XPLACEDFE_OFC140_n881 BUFX3TR $PINS A=n881 Y=FE_OFN33_n881
XPLACEDFE_OFC139_n1098 CLKBUFX2TR $PINS A=FE_OFN20_n1098 Y=FE_OFN96_n1098
XPLACEDFE_OFC138_n1098 CLKINVX2TR $PINS A=FE_OFN19_n1098 Y=FE_OFN95_n1098
XPLACEDFE_OFC137_n1098 CLKINVX6TR $PINS A=FE_OFN19_n1098 Y=FE_OFN20_n1098
XPLACEDFE_OFC136_n1098 CLKINVX2TR $PINS A=n1098 Y=FE_OFN19_n1098
XPLACEDFE_OFC135_n955 CLKINVX2TR $PINS A=FE_OFN38_n955 Y=FE_OFN94_n955
XPLACEDFE_OFC134_n955 CLKINVX2TR $PINS A=FE_OFN38_n955 Y=FE_OFN93_n955
XPLACEDFE_OFC133_n955 CLKINVX2TR $PINS A=FE_OFN37_n955 Y=FE_OFN38_n955
XPLACEDFE_OFC132_n955 BUFX3TR $PINS A=n955 Y=FE_OFN37_n955
XPLACEDFE_OFC128_pe_in_pk_rdb_addr__2 CLKINVX2TR $PINS A=n1078
+ Y=FE_OFN89_pe_in_pk_rdb_addr__2
XPLACEDFE_OFC127_pe_in_pk_rdb_addr__2 INVX2TR $PINS A=pe_in_pk_rdb_addr__2_
+ Y=n1078
XPLACEDFE_OFC126_n963 INVX2TR $PINS A=FE_OFN86_n963 Y=FE_OFN88_n963
XPLACEDFE_OFC125_n963 CLKINVX2TR $PINS A=FE_OFN86_n963 Y=FE_OFN87_n963
XPLACEDFE_OFC124_n963 CLKINVX2TR $PINS A=FE_OFN41_n963 Y=FE_OFN86_n963
XPLACEDFE_OFC123_n963 CLKBUFX2TR $PINS A=FE_OFN41_n963 Y=FE_OFN42_n963
XPLACEDFE_OFC122_n963 CLKBUFX2TR $PINS A=n963 Y=FE_OFN41_n963
XPLACEDFE_OFC121_n959 BUFX3TR $PINS A=FE_OFN40_n959 Y=FE_OFN85_n959
XPLACEDFE_OFC120_n959 BUFX3TR $PINS A=FE_OFN39_n959 Y=FE_OFN40_n959
XPLACEDFE_OFC119_n959 CLKBUFX2TR $PINS A=n959 Y=FE_OFN39_n959
XPLACEDFE_OFC118_n975 CLKBUFX2TR $PINS A=FE_OFN83_n975 Y=FE_OFN84_n975
XPLACEDFE_OFC117_n975 CLKINVX2TR $PINS A=FE_OFN47_n975 Y=FE_OFN83_n975
XPLACEDFE_OFC115_n975 CLKINVX2TR $PINS A=FE_OFN47_n975 Y=FE_OFN48_n975
XPLACEDFE_OFC114_n975 CLKINVX2TR $PINS A=n975 Y=FE_OFN47_n975
XPLACEDFE_OFC111_n1080 CLKBUFX2TR $PINS A=FE_OFN12_n1080 Y=FE_OFN80_n1080
XPLACEDFE_OFC110_n1080 CLKBUFX2TR $PINS A=FE_OFN12_n1080 Y=FE_OFN13_n1080
XPLACEDFE_OFC109_n1080 BUFX3TR $PINS A=n1080 Y=FE_OFN12_n1080
XPLACEDFE_OFC106_n1096 CLKINVX2TR $PINS A=FE_OFN15_n1096 Y=FE_OFN16_n1096
XPLACEDFE_OFC104_n891 CLKINVX2TR $PINS A=n1041 Y=FE_OFN78_n891
XPLACEDFE_OFC103_n891 CLKINVX2TR $PINS A=n1041 Y=FE_OFN77_n891
XPLACEDFE_OFC102_n891 CLKINVX2TR $PINS A=n1041 Y=FE_OFN76_n891
XPLACEDFE_OFC101_n891 CLKINVX2TR $PINS A=n1041 Y=FE_OFN75_n891
XPLACEDFE_OFC100_n891 CLKINVX2TR $PINS A=n1041 Y=FE_OFN74_n891
XPLACEDFE_OFC99_n891 INVX2TR $PINS A=n891 Y=n1041
XPLACEDFE_OFC98_n949 INVX2TR $PINS A=FE_OFN36_n949 Y=FE_OFN73_n949
XPLACEDFE_OFC97_n949 CLKINVX2TR $PINS A=FE_OFN36_n949 Y=FE_OFN72_n949
XPLACEDFE_OFC96_n949 INVX2TR $PINS A=FE_OFN35_n949 Y=FE_OFN36_n949
XPLACEDFE_OFC95_n949 BUFX3TR $PINS A=n949 Y=FE_OFN35_n949
XPLACEDFE_OFC94_pe_in_pk_rdb_addr__0 INVX2TR $PINS A=n1079
+ Y=FE_OFN71_pe_in_pk_rdb_addr__0
XPLACEDFE_OFC93_pe_in_pk_rdb_addr__0 INVX2TR $PINS A=pe_in_pk_rdb_addr__0_
+ Y=n1079
XPLACEDFE_OFC92_n918 CLKINVX1TR $PINS A=n918 Y=FE_OFN70_n918
XPLACEDFE_OFC90_n918 INVX4TR $PINS A=n918 Y=n1003
XPLACEDFE_OFC89_n947 CLKINVX2TR $PINS A=n996 Y=FE_OFN68_n947
XPLACEDFE_OFC88_n947 CLKINVX2TR $PINS A=n996 Y=FE_OFN67_n947
XPLACEDFE_OFC87_n947 CLKINVX2TR $PINS A=n996 Y=FE_OFN66_n947
XPLACEDFE_OFC86_n947 CLKINVX2TR $PINS A=n996 Y=FE_OFN65_n947
XPLACEDFE_OFC85_n947 CLKINVX2TR $PINS A=n996 Y=FE_OFN64_n947
XPLACEDFE_OFC84_n947 INVX2TR $PINS A=n947 Y=n996
XPLACEDFE_OFC83_n916 INVX2TR $PINS A=n916 Y=FE_OFN63_n916
XPLACEDFE_OFC80_n928 INVX2TR $PINS A=n928 Y=n1013
XPLACEDFE_OFC79_n1099 CLKBUFX2TR $PINS A=FE_OFN21_n1099 Y=FE_OFN22_n1099
XPLACEDFE_OFC78_n1099 CLKBUFX2TR $PINS A=n1099 Y=FE_OFN21_n1099
XPLACEDFE_OFC77_n912 INVX2TR $PINS A=n992 Y=FE_OFN61_n912
XPLACEDFE_OFC76_n912 INVX2TR $PINS A=n912 Y=n992
XPLACEDFE_OFC75_n904 INVX2TR $PINS A=n1045 Y=FE_OFN60_n904
XPLACEDFE_OFC74_n904 CLKINVX2TR $PINS A=n904 Y=n1045
XPLACEDFE_OFC73_n935 CLKINVX2TR $PINS A=n998 Y=FE_OFN59_n935
XPLACEDFE_OFC71_n935 INVX2TR $PINS A=n935 Y=n998
XPLACEDFE_OFC70_n890 INVX2TR $PINS A=FE_OFN50_n890 Y=n1039
XPLACEDFE_OFC69_n890 BUFX4TR $PINS A=n890 Y=FE_OFN50_n890
XPLACEDFE_OFC66_n886 INVX2TR $PINS A=n1032 Y=FE_OFN57_n886
XPLACEDFE_OFC65_n886 CLKBUFX2TR $PINS A=n886 Y=n1032
XPLACEDFE_OFC64_n923 INVX4TR $PINS A=n923 Y=FE_OFN56_n923
XPLACEDFE_OFC62_n1097 BUFX3TR $PINS A=FE_OFN18_n1097 Y=FE_OFN55_n1097
XPLACEDFE_OFC61_n1097 CLKINVX2TR $PINS A=FE_OFN17_n1097 Y=FE_OFN54_n1097
XPLACEDFE_OFC60_n1097 INVX2TR $PINS A=FE_OFN17_n1097 Y=FE_OFN18_n1097
XPLACEDFE_OFC59_n1097 CLKINVX1TR $PINS A=n1097 Y=FE_OFN17_n1097
XPLACEDFE_OFC58_n903 INVX2TR $PINS A=n903 Y=n978
XPLACEDFE_OFC57_n1101 BUFX3TR $PINS A=FE_OFN52_n1101 Y=FE_OFN53_n1101
XPLACEDFE_OFC56_n1101 INVX2TR $PINS A=FE_OFN25_n1101 Y=FE_OFN52_n1101
XPLACEDFE_OFC55_n1101 CLKINVX2TR $PINS A=FE_OFN25_n1101 Y=FE_OFN26_n1101
XPLACEDFE_OFC54_n1101 CLKINVX2TR $PINS A=n1101 Y=FE_OFN25_n1101
XPLACEDFE_OFC7_reset CLKBUFX2TR $PINS A=FE_OFN4_reset Y=FE_OFN7_reset
XPLACEDFE_OFC4_reset CLKBUFX2TR $PINS A=FE_OFN6_reset Y=FE_OFN4_reset
XPLACEDFE_OFC0_FE_DBTN0_n2195 BUFX3TR $PINS A=FE_DBTN0_n2195
+ Y=FE_OFN0_FE_DBTN0_n2195
XPLACEDFE_DBTC0_n2195 INVX2TR $PINS A=n2195 Y=FE_DBTN0_n2195
Xclk_r_REG12_S3 DFFQX1TR $PINS D=n1727 CK=CTS_12 Q=n2232
Xclk_r_REG577_S1 DFFQX1TR $PINS D=n1717 CK=CTS_9 Q=n2222
Xclk_r_REG572_S1 DFFQX1TR $PINS D=n1712 CK=CTS_6 Q=n2217
Xclk_r_REG559_S1 DFFQX1TR $PINS D=n1709 CK=CTS_3 Q=n2214
Xclk_r_REG556_S1 DFFQX1TR $PINS D=n1706 CK=CTS_6 Q=n2211
Xclk_r_REG549_S1 DFFQX1TR $PINS D=n1699 CK=CTS_1 Q=n2204
Xclk_r_REG568_S1 DFFQX1TR $PINS D=n1698 CK=CTS_2 Q=n2203
Xclk_r_REG567_S1 DFFQX1TR $PINS D=n1697 CK=CTS_7 Q=n2202
Xclk_r_REG566_S1 DFFQX1TR $PINS D=n1696 CK=CTS_9 Q=n2201
Xclk_r_REG450_S1 DFFHQX1TR $PINS D=FE_OFN32_FE_DBTN1_reset CK=CTS_7 Q=n2195
Xclk_r_REG325_S1 DFFQX1TR $PINS D=n1685 CK=CTS_12 Q=n2188
Xclk_r_REG344_S1 DFFQX1TR $PINS D=n1682 CK=CTS_6 Q=n2184
Xclk_r_REG343_S1 DFFQX1TR $PINS D=n1681 CK=CTS_6 Q=n2183
Xclk_r_REG349_S1 DFFQX1TR $PINS D=n1652 CK=CTS_6 Q=n2152
Xclk_r_REG300_S1 DFFQX1TR $PINS D=n1646 CK=CTS_6 Q=n2144
Xclk_r_REG299_S1 DFFQX1TR $PINS D=n1645 CK=CTS_6 Q=n2143
Xclk_r_REG305_S1 DFFQX1TR $PINS D=n1616 CK=CTS_6 Q=n2112
Xclk_r_REG256_S1 DFFQX1TR $PINS D=n1610 CK=CTS_3 Q=n2104
Xclk_r_REG255_S1 DFFQX1TR $PINS D=n1609 CK=CTS_6 Q=n2103
Xclk_r_REG261_S1 DFFQX1TR $PINS D=n1580 CK=CTS_6 Q=n2072
Xclk_r_REG209_S1 DFFQX1TR $PINS D=n1574 CK=CTS_6 Q=n2064
Xclk_r_REG208_S1 DFFQX1TR $PINS D=n1573 CK=CTS_6 Q=n2063
Xclk_r_REG203_S1 DFFQX1TR $PINS D=n1568 CK=CTS_6 Q=n2058
Xclk_r_REG202_S1 DFFQX1TR $PINS D=n1567 CK=CTS_6 Q=n2057
Xclk_r_REG199_S1 DFFQX1TR $PINS D=n1564 CK=CTS_7 Q=n2054
Xclk_r_REG198_S1 DFFQX1TR $PINS D=n1563 CK=CTS_9 Q=n2053
Xclk_r_REG197_S1 DFFQX1TR $PINS D=n1562 CK=CTS_9 Q=n2052
Xclk_r_REG196_S1 DFFQX1TR $PINS D=n1561 CK=CTS_9 Q=n2051
Xclk_r_REG195_S1 DFFQX1TR $PINS D=n1560 CK=CTS_9 Q=n2050
Xclk_r_REG232_S2 DFFQX1TR $PINS D=n2049 CK=CTS_11 Q=n2048
Xclk_r_REG227_S1 DFFQX1TR $PINS D=n1555 CK=CTS_3 Q=n2043
Xclk_r_REG226_S1 DFFQX1TR $PINS D=n1554 CK=CTS_3 Q=n2042
Xclk_r_REG216_S1 DFFQX1TR $PINS D=n1544 CK=CTS_6 Q=n2032
Xclk_r_REG137_S1 DFFQX1TR $PINS D=n1543 CK=CTS_7 Q=n2031
Xclk_r_REG136_S1 DFFQX1TR $PINS D=n1542 CK=CTS_9 Q=n2029
Xclk_r_REG135_S1 DFFQX1TR $PINS D=n1541 CK=CTS_12 Q=n2028
Xclk_r_REG134_S1 DFFQX1TR $PINS D=n1540 CK=CTS_12 Q=n2027
Xclk_r_REG155_S1 DFFQX1TR $PINS D=n1539 CK=CTS_2 Q=n2026
Xclk_r_REG154_S1 DFFQX1TR $PINS D=n1538 CK=CTS_6 Q=n2024
Xclk_r_REG153_S1 DFFQX1TR $PINS D=n1537 CK=CTS_6 Q=n2023
Xclk_r_REG152_S1 DFFQX1TR $PINS D=n1536 CK=CTS_1 Q=n2022
Xclk_r_REG151_S1 DFFQX1TR $PINS D=n1535 CK=CTS_1 Q=n2021
Xclk_r_REG150_S1 DFFQX1TR $PINS D=n1534 CK=CTS_12 Q=n2020
Xclk_r_REG149_S1 DFFQX2TR $PINS D=n1533 CK=CTS_12 Q=n2019
Xclk_r_REG148_S1 DFFQX1TR $PINS D=n1532 CK=CTS_12 Q=n2018
Xclk_r_REG147_S1 DFFQX1TR $PINS D=n1531 CK=CTS_1 Q=n2017
Xclk_r_REG146_S1 DFFQX1TR $PINS D=n1530 CK=CTS_6 Q=n2016
Xclk_r_REG145_S1 DFFQX1TR $PINS D=n1529 CK=CTS_6 Q=n2015
Xclk_r_REG144_S1 DFFQX1TR $PINS D=n1528 CK=CTS_1 Q=n2014
Xclk_r_REG143_S1 DFFQX1TR $PINS D=n1527 CK=CTS_9 Q=n2013
Xclk_r_REG142_S1 DFFQX1TR $PINS D=n1526 CK=CTS_9 Q=n2012
Xclk_r_REG141_S1 DFFQX1TR $PINS D=n1525 CK=CTS_9 Q=n2011
Xclk_r_REG140_S1 DFFQX1TR $PINS D=n1524 CK=CTS_9 Q=n2010
Xclk_r_REG177_S1 DFFQX1TR $PINS D=n1523 CK=CTS_11 Q=n2009
Xclk_r_REG176_S1 DFFQX1TR $PINS D=n1522 CK=CTS_6 Q=n2007
Xclk_r_REG175_S1 DFFQX1TR $PINS D=n1521 CK=CTS_11 Q=n2005
Xclk_r_REG173_S1 DFFQX1TR $PINS D=n1519 CK=CTS_3 Q=n2003
Xclk_r_REG172_S1 DFFQX2TR $PINS D=n1518 CK=CTS_3 Q=n2002
Xclk_r_REG168_S1 DFFQX1TR $PINS D=n1514 CK=CTS_8 Q=n1998
Xclk_r_REG167_S1 DFFQX1TR $PINS D=n1513 CK=CTS_8 Q=n1997
Xclk_r_REG166_S1 DFFQX1TR $PINS D=n1512 CK=CTS_11 Q=n1996
Xclk_r_REG162_S1 DFFQX1TR $PINS D=n1508 CK=CTS_6 Q=n1992
Xclk_r_REG4_S1 DFFQX1TR $PINS D=n1507 CK=CTS_7 Q=n1991
Xclk_r_REG5_S2 DFFQX1TR $PINS D=n1991 CK=CTS_7 Q=n1990
Xclk_r_REG3_S1 DFFQX1TR $PINS D=n1506 CK=CTS_9 Q=n1989
Xclk_r_REG2_S1 DFFQX1TR $PINS D=n1505 CK=CTS_9 Q=n1988
Xclk_r_REG1_S1 DFFQX1TR $PINS D=n1504 CK=CTS_9 Q=n1987
Xclk_r_REG68_S1 DFFQX1TR $PINS D=n1503 CK=CTS_2 Q=n1986
Xclk_r_REG67_S1 DFFQX1TR $PINS D=n1502 CK=CTS_6 Q=n1984
Xclk_r_REG66_S1 DFFQX1TR $PINS D=n1501 CK=CTS_6 Q=n1983
Xclk_r_REG65_S1 DFFQX1TR $PINS D=n1500 CK=CTS_1 Q=n1982
Xclk_r_REG64_S1 DFFQX1TR $PINS D=n1499 CK=CTS_1 Q=n1981
Xclk_r_REG63_S1 DFFQX1TR $PINS D=n1498 CK=CTS_12 Q=n1980
Xclk_r_REG62_S1 DFFQX1TR $PINS D=n1497 CK=CTS_12 Q=n1979
Xclk_r_REG61_S1 DFFQX1TR $PINS D=n1496 CK=CTS_1 Q=n1978
Xclk_r_REG60_S1 DFFQX2TR $PINS D=n1495 CK=CTS_1 Q=n1977
Xclk_r_REG59_S1 DFFQX1TR $PINS D=n1494 CK=CTS_1 Q=n1976
Xclk_r_REG58_S1 DFFQX1TR $PINS D=n1493 CK=CTS_6 Q=n1975
Xclk_r_REG57_S1 DFFQX1TR $PINS D=n1492 CK=CTS_7 Q=n1974
Xclk_r_REG56_S1 DFFQX1TR $PINS D=n1491 CK=CTS_9 Q=n1973
Xclk_r_REG55_S1 DFFQX1TR $PINS D=n1490 CK=CTS_9 Q=n1972
Xclk_r_REG54_S1 DFFQX1TR $PINS D=n1489 CK=CTS_9 Q=n1971
Xclk_r_REG53_S1 DFFQX1TR $PINS D=n1488 CK=CTS_9 Q=n1970
Xclk_r_REG111_S1 DFFQX1TR $PINS D=n1487 CK=CTS_11 Q=n1969
Xclk_r_REG112_S2 DFFQX1TR $PINS D=n1969 CK=CTS_11 Q=n1968
Xclk_r_REG110_S1 DFFQX1TR $PINS D=n1486 CK=CTS_2 Q=n1967
Xclk_r_REG124_S2 DFFQX1TR $PINS D=n1967 CK=CTS_2 Q=n1966
Xclk_r_REG109_S1 DFFQX1TR $PINS D=n1485 CK=CTS_11 Q=n1965
Xclk_r_REG108_S1 DFFQX1TR $PINS D=n1484 CK=CTS_8 Q=n1964
Xclk_r_REG107_S1 DFFQX1TR $PINS D=n1483 CK=CTS_3 Q=n1963
Xclk_r_REG106_S1 DFFQX1TR $PINS D=n1482 CK=CTS_3 Q=n1962
Xclk_r_REG105_S1 DFFQX1TR $PINS D=n1481 CK=CTS_8 Q=n1961
Xclk_r_REG104_S1 DFFQX1TR $PINS D=n1480 CK=CTS_8 Q=n1960
Xclk_r_REG103_S1 DFFQX1TR $PINS D=n1479 CK=CTS_8 Q=n1959
Xclk_r_REG102_S1 DFFQX1TR $PINS D=n1478 CK=CTS_8 Q=n1958
Xclk_r_REG101_S1 DFFQX1TR $PINS D=n1477 CK=CTS_8 Q=n1957
Xclk_r_REG100_S1 DFFQX1TR $PINS D=n1476 CK=CTS_8 Q=n1956
Xclk_r_REG99_S1 DFFQX1TR $PINS D=n1475 CK=CTS_3 Q=n1955
Xclk_r_REG97_S1 DFFQX1TR $PINS D=n1473 CK=CTS_6 Q=n1953
Xclk_r_REG96_S1 DFFQX1TR $PINS D=n1472 CK=CTS_6 Q=n1952
Xclk_r_REG504_S1 DFFQX1TR $PINS D=n1471 CK=CTS_7 Q=n1951
Xclk_r_REG503_S1 DFFQX1TR $PINS D=n1470 CK=CTS_9 Q=n1949
Xclk_r_REG502_S1 DFFQX1TR $PINS D=n1469 CK=CTS_9 Q=n1948
Xclk_r_REG501_S1 DFFQX1TR $PINS D=n1468 CK=CTS_9 Q=n1947
Xclk_r_REG522_S1 DFFQX1TR $PINS D=n1467 CK=CTS_2 Q=n1946
Xclk_r_REG520_S1 DFFQX1TR $PINS D=n1465 CK=CTS_6 Q=n1943
Xclk_r_REG519_S1 DFFQX1TR $PINS D=n1464 CK=CTS_7 Q=n1942
Xclk_r_REG518_S1 DFFQX1TR $PINS D=n1463 CK=CTS_1 Q=n1941
Xclk_r_REG517_S1 DFFQX1TR $PINS D=n1462 CK=CTS_12 Q=n1940
Xclk_r_REG516_S1 DFFQX1TR $PINS D=n1461 CK=CTS_12 Q=n1939
Xclk_r_REG515_S1 DFFQX1TR $PINS D=n1460 CK=CTS_12 Q=n1938
Xclk_r_REG514_S1 DFFQX2TR $PINS D=n1459 CK=CTS_12 Q=n1937
Xclk_r_REG513_S1 DFFQX1TR $PINS D=n1458 CK=CTS_6 Q=n1936
Xclk_r_REG512_S1 DFFQX1TR $PINS D=n1457 CK=CTS_6 Q=n1935
Xclk_r_REG511_S1 DFFQX1TR $PINS D=n1456 CK=CTS_9 Q=n1934
Xclk_r_REG510_S1 DFFQX1TR $PINS D=n1455 CK=CTS_9 Q=n1933
Xclk_r_REG509_S1 DFFQX1TR $PINS D=n1454 CK=CTS_9 Q=n1932
Xclk_r_REG508_S1 DFFQX1TR $PINS D=n1453 CK=CTS_9 Q=n1931
Xclk_r_REG507_S1 DFFQX1TR $PINS D=n1452 CK=CTS_9 Q=n1930
Xclk_r_REG539_S1 DFFQX1TR $PINS D=n1449 CK=CTS_8 Q=n1925
Xclk_r_REG538_S1 DFFQX1TR $PINS D=n1448 CK=CTS_8 Q=n1924
Xclk_r_REG537_S1 DFFQX1TR $PINS D=n1447 CK=CTS_3 Q=n1923
Xclk_r_REG536_S1 DFFQX1TR $PINS D=n1446 CK=CTS_3 Q=n1922
Xclk_r_REG533_S1 DFFQX1TR $PINS D=n1443 CK=CTS_8 Q=n1919
Xclk_r_REG526_S1 DFFQX1TR $PINS D=n1436 CK=CTS_6 Q=n1912
Xclk_r_REG460_S1 DFFQX1TR $PINS D=n1435 CK=CTS_7 Q=n1911
Xclk_r_REG459_S1 DFFQX1TR $PINS D=n1434 CK=CTS_9 Q=n1909
Xclk_r_REG458_S1 DFFQX1TR $PINS D=n1433 CK=CTS_9 Q=n1908
Xclk_r_REG457_S1 DFFQX1TR $PINS D=n1432 CK=CTS_9 Q=n1907
Xclk_r_REG478_S1 DFFQX1TR $PINS D=n1431 CK=CTS_2 Q=n1906
Xclk_r_REG476_S1 DFFQX1TR $PINS D=n1429 CK=CTS_6 Q=n1903
Xclk_r_REG475_S1 DFFQX1TR $PINS D=n1428 CK=CTS_1 Q=n1902
Xclk_r_REG474_S1 DFFQX1TR $PINS D=n1427 CK=CTS_1 Q=n1901
Xclk_r_REG473_S1 DFFQX1TR $PINS D=n1426 CK=CTS_3 Q=n1900
Xclk_r_REG472_S1 DFFQX1TR $PINS D=n1425 CK=CTS_6 Q=n1899
Xclk_r_REG471_S1 DFFQX1TR $PINS D=n1424 CK=CTS_1 Q=n1898
Xclk_r_REG470_S1 DFFQX1TR $PINS D=n1423 CK=CTS_1 Q=n1897
Xclk_r_REG469_S1 DFFQX1TR $PINS D=n1422 CK=CTS_6 Q=n1896
Xclk_r_REG468_S1 DFFQX1TR $PINS D=n1421 CK=CTS_6 Q=n1895
Xclk_r_REG467_S1 DFFQX1TR $PINS D=n1420 CK=CTS_7 Q=n1894
Xclk_r_REG466_S1 DFFQX1TR $PINS D=n1419 CK=CTS_9 Q=n1893
Xclk_r_REG465_S1 DFFQX1TR $PINS D=n1418 CK=CTS_9 Q=n1892
Xclk_r_REG464_S1 DFFQX1TR $PINS D=n1417 CK=CTS_9 Q=n1891
Xclk_r_REG463_S1 DFFQX1TR $PINS D=n1416 CK=CTS_9 Q=n1890
Xclk_r_REG497_S1 DFFQX1TR $PINS D=n1415 CK=CTS_11 Q=n1889
Xclk_r_REG498_S2 DFFQX1TR $PINS D=n1889 CK=CTS_11 Q=n1888
Xclk_r_REG496_S1 DFFQX1TR $PINS D=n1414 CK=CTS_2 Q=n1887
Xclk_r_REG495_S1 DFFQX1TR $PINS D=n1413 CK=CTS_8 Q=n1885
Xclk_r_REG494_S1 DFFQX1TR $PINS D=n1412 CK=CTS_8 Q=n1884
Xclk_r_REG493_S1 DFFQX1TR $PINS D=n1411 CK=CTS_3 Q=n1883
Xclk_r_REG492_S1 DFFQX1TR $PINS D=n1410 CK=CTS_3 Q=n1882
Xclk_r_REG489_S1 DFFQX1TR $PINS D=n1407 CK=CTS_8 Q=n1879
Xclk_r_REG482_S1 DFFQX1TR $PINS D=n1400 CK=CTS_6 Q=n1872
Xclk_r_REG41_S1 DFFQX1TR $PINS D=n1395 CK=CTS_7 Q=n1871
Xclk_r_REG569_S1 DFFQX1TR $PINS D=FE_OFN32_FE_DBTN1_reset CK=CTS_7 Q=n1866
Xclk_r_REG452_S1 DFFQX1TR $PINS D=FE_OFN114_reset CK=CTS_7 Q=n1865
Xclk_r_REG179_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out_int_4_
+ CK=CTS_7 Q=n1864
Xclk_r_REG159_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out_int_4_
+ CK=CTS_2 Q=n1863
Xclk_r_REG157_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<4>
+ CK=CTS_1 Q=n1861
Xclk_r_REG127_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<4>
+ CK=CTS_7 Q=n1859
Xclk_r_REG455_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__7_ CK=CTS_5 Q=n1858
Xclk_r_REG447_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__6_ CK=CTS_5 Q=n1857
Xclk_r_REG445_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__5_ CK=CTS_5 Q=n1856
Xclk_r_REG443_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__4_ CK=CTS_5 Q=n1855
Xclk_r_REG441_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__3_ CK=CTS_5 Q=n1854
Xclk_r_REG439_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__2_ CK=CTS_5 Q=n1853
Xclk_r_REG437_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__1_ CK=CTS_5 Q=n1852
Xclk_r_REG435_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__3__0_ CK=CTS_5 Q=n1851
Xclk_r_REG433_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__7_ CK=CTS_5 Q=n1850
Xclk_r_REG431_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__6_ CK=CTS_5 Q=n1849
Xclk_r_REG429_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__5_ CK=CTS_5 Q=n1848
Xclk_r_REG427_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__4_ CK=CTS_5 Q=n1847
Xclk_r_REG425_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__3_ CK=CTS_5 Q=n1846
Xclk_r_REG423_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__2_ CK=CTS_5 Q=n1845
Xclk_r_REG421_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__1_ CK=CTS_5 Q=n1844
Xclk_r_REG419_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__2__0_ CK=CTS_5 Q=n1843
Xclk_r_REG417_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__7_ CK=CTS_5 Q=n1842
Xclk_r_REG415_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__6_ CK=CTS_5 Q=n1841
Xclk_r_REG413_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__5_ CK=CTS_5 Q=n1840
Xclk_r_REG412_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__4_ CK=CTS_5 Q=n1839
Xclk_r_REG410_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__3_ CK=CTS_5 Q=n1838
Xclk_r_REG408_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__2_ CK=CTS_5 Q=n1837
Xclk_r_REG406_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__1_ CK=CTS_5 Q=n1836
Xclk_r_REG404_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__1__0_ CK=CTS_5 Q=n1835
Xclk_r_REG403_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__7_ CK=CTS_11 Q=n1834
Xclk_r_REG401_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__6_ CK=CTS_11 Q=n1833
Xclk_r_REG399_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__5_ CK=CTS_11 Q=n1832
Xclk_r_REG397_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__4_ CK=CTS_11 Q=n1831
Xclk_r_REG395_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__3_ CK=CTS_11 Q=n1830
Xclk_r_REG393_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__2_ CK=CTS_11 Q=n1829
Xclk_r_REG391_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__1_ CK=CTS_11 Q=n1828
Xclk_r_REG389_S1 DFFQX1TR $PINS D=pe_in_pk_int_A__0__0_ CK=CTS_11 Q=n1827
Xclk_r_REG384_S3 DFFQX1TR $PINS D=PE_top0_ST_ADD<0> CK=CTS_3 Q=n1822
Xclk_r_REG385_S4 DFFQX1TR $PINS D=pe_out_pk_PE_state__0_ CK=CTS_12 Q=n1819
Xclk_r_REG379_S3 DFFQX1TR $PINS D=pe_out_pk_PE_state__1_ CK=CTS_12 Q=n1818
Xclk_r_REG373_S3 DFFQX1TR $PINS D=pe_out_pk_PE_state__2_ CK=CTS_12 Q=n1817
Xclk_r_REG383_S2 DFFQX1TR $PINS D=PE_top0_ST_MULT<0> CK=CTS_3 Q=n1816
Xclk_r_REG377_S1 DFFQX1TR $PINS D=PE_top0_ST_MULT<1> CK=CTS_3 Q=n1815
Xclk_r_REG371_S1 DFFQX1TR $PINS D=PE_top0_ST_MULT<2> CK=CTS_3 Q=n1814
Xclk_r_REG382_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<0> CK=CTS_2
+ Q=n1813
Xclk_r_REG376_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<1> CK=CTS_2
+ Q=n1812
Xclk_r_REG370_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<2> CK=CTS_2
+ Q=n1811
Xclk_r_REG381_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<0> CK=CTS_2
+ Q=n1810
Xclk_r_REG375_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<1> CK=CTS_2
+ Q=n1809
Xclk_r_REG369_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<2> CK=CTS_2
+ Q=n1808
Xclk_r_REG131_S3 DFFQX1TR $PINS D=n1397 CK=CTS_3 Q=n1805
Xclk_r_REG192_S3 DFFQX1TR $PINS D=n1396 CK=CTS_3 Q=n1804
Xclk_r_REG11_S3 DFFQX1TR $PINS D=pe_out_pk_data__7_ CK=CTS_12 Q=n1803
Xclk_r_REG14_S3 DFFQX1TR $PINS D=pe_out_pk_data__6_ CK=CTS_12 Q=n1802
Xclk_r_REG17_S3 DFFQX1TR $PINS D=pe_out_pk_data__5_ CK=CTS_12 Q=n1800
Xclk_r_REG20_S3 DFFQX1TR $PINS D=pe_out_pk_data__4_ CK=CTS_12 Q=n1798
Xclk_r_REG23_S3 DFFQX1TR $PINS D=pe_out_pk_data__3_ CK=CTS_12 Q=n1796
Xclk_r_REG9_S3 DFFQX1TR $PINS D=pe_out_pk_data__2_ CK=CTS_3 Q=n1794
Xclk_r_REG130_S3 DFFQX1TR $PINS D=pe_out_pk_data__1_ CK=CTS_3 Q=n1792
Xclk_r_REG191_S3 DFFQX1TR $PINS D=pe_out_pk_data__0_ CK=CTS_3 Q=n1790
Xclk_r_REG28_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<7> CK=CTS_12 Q=n1788
Xclk_r_REG29_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<6> CK=CTS_12 Q=n1787
Xclk_r_REG129_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<1> CK=CTS_3 Q=n1782
Xclk_r_REG188_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out1_0_ CK=CTS_7
+ Q=n1780
Xclk_r_REG212_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out1_0_ CK=CTS_1
+ Q=n1779
Xclk_r_REG214_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out1_0_ CK=CTS_2
+ Q=n1778
Xclk_r_REG233_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out1_0_ CK=CTS_7
+ Q=n1777
Xclk_r_REG189_S1 DFFQX1TR $PINS D=PE_top0_adder0_out_int2<0> CK=CTS_1 Q=n1776
Xclk_r_REG7_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n35 CK=CTS_1
+ Q=n1774
Xclk_r_REG32_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n34 CK=CTS_1
+ Q=n1773
Xclk_r_REG33_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n32 CK=CTS_1
+ Q=n1772
Xclk_r_REG34_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n31 CK=CTS_1
+ Q=n1771
Xclk_r_REG39_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n24 CK=CTS_7
+ Q=n1767
Xclk_r_REG40_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n18 CK=CTS_7
+ Q=n1766
Xclk_r_REG133_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n37 CK=CTS_1
+ Q=n1760
Xclk_r_REG323_S2 DFFQX1TR $PINS D=n2273 CK=CTS_11 Q=n1758
Xclk_r_REG279_S2 DFFQX1TR $PINS D=n2272 CK=CTS_11 Q=n1757
Xclk_r_REG235_S2 DFFQX1TR $PINS D=n2271 CK=CTS_11 Q=n1756
Xclk_r_REG125_S2 DFFQX1TR $PINS D=n2269 CK=CTS_11 Q=n1754
Xclk_r_REG500_S2 DFFQX1TR $PINS D=n2266 CK=CTS_8 Q=n1752
Xclk_r_REG303_S2 DFFQX1TR $PINS D=n2263 CK=CTS_2 Q=n1750
Xclk_r_REG259_S2 DFFQX1TR $PINS D=n2262 CK=CTS_6 Q=n1749
Xclk_r_REG82_S2 DFFQX1TR $PINS D=n2259 CK=CTS_6 Q=n1746
Xclk_r_REG260_S2 DFFQX1TR $PINS D=n2252 CK=CTS_2 Q=n1741
Xclk_r_REG215_S2 DFFQX1TR $PINS D=n2251 CK=CTS_1 Q=n1740
Xclk_r_REG139_S2 DFFQX1TR $PINS D=n2240 CK=CTS_7 Q=n1731
Xclk_r_REG52_S2 DFFQX1TR $PINS D=n2239 CK=CTS_7 Q=n1730
Xclk_r_REG462_S2 DFFQX1TR $PINS D=n2236 CK=CTS_7 Q=n1728
Xclk_r_REG387_S2 DFFHQX2TR $PINS D=n2235 CK=CTS_7 Q=n1764
Xclk_r_REG545_S1 DFFHQX2TR $PINS D=n2237 CK=CTS_7 Q=n1870
Xclk_r_REG546_S1 DFFHQX1TR $PINS D=n2247 CK=CTS_2 Q=n1869
Xclk_r_REG548_S1 DFFHQX1TR $PINS D=n2267 CK=CTS_11 Q=n1867
Xclk_r_REG453_S1 DFFQX4TR $PINS D=n2245 CK=CTS_1 Q=n1763
Xclk_r_REG449_S2 DFFHQX1TR $PINS D=n2265 CK=CTS_11 Q=n1761
Xclk_r_REG547_S1 DFFHQX2TR $PINS D=n2257 CK=CTS_2 Q=n1868
Xclk_r_REG454_S1 DFFQX4TR $PINS D=n2255 CK=CTS_2 Q=n1762
Xclk_r_REG374_S4 DFFQX1TR $PINS D=n2276 CK=CTS_9 Q=pk_out_PE_state__2_
Xclk_r_REG380_S4 DFFQX1TR $PINS D=n2277 CK=CTS_9 Q=pk_out_PE_state__1_
Xclk_r_REG386_S5 DFFQX1TR $PINS D=n2278 CK=CTS_9 Q=pk_out_PE_state__0_
Xclk_r_REG13_S4 DFFQX1TR $PINS D=n2275 CK=CTS_12 Q=n1823
Xclk_r_REG16_S4 DFFQX1TR $PINS D=n1802 CK=CTS_12 Q=n1801
Xclk_r_REG19_S4 DFFQX1TR $PINS D=n1800 CK=CTS_12 Q=n1799
Xclk_r_REG22_S4 DFFQX1TR $PINS D=n1798 CK=CTS_12 Q=n1797
Xclk_r_REG25_S4 DFFQX1TR $PINS D=n1796 CK=CTS_12 Q=n1795
Xclk_r_REG26_S4 DFFQX1TR $PINS D=n1794 CK=CTS_3 Q=n1793
Xclk_r_REG132_S4 DFFQX1TR $PINS D=n1792 CK=CTS_3 Q=n1791
Xclk_r_REG193_S4 DFFQX1TR $PINS D=n1790 CK=CTS_3 Q=n1789
Xclk_r_REG158_S2 DFFQX1TR $PINS D=n2260 CK=CTS_6 Q=n1747
Xclk_r_REG181_S2 DFFQX1TR $PINS D=n2007 CK=CTS_6 Q=n2006
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG180_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n39 CK=CTS_7 Q=n1394
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG115_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n7 CK=CTS_7 Q=n1393
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG116_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n30 CK=CTS_7 Q=n1391
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG117_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n29 CK=CTS_7 Q=n1390
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG120_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n22 CK=CTS_7 Q=n1388
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG121_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n19 CK=CTS_11 Q=n1387
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG392_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<1> CK=CTS_11 Q=n1384
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG394_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<2> CK=CTS_11 Q=n1383
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG396_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<3> CK=CTS_11 Q=n1382
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG400_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<5> CK=CTS_11 Q=n1380
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG402_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<6> CK=CTS_11 Q=n1379
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG368_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<7> CK=CTS_11 Q=n1378
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG160_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n39 CK=CTS_2 Q=n1377
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG83_S3 DFFHQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n32 CK=CTS_2 Q=n1376
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG84_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n7 CK=CTS_2 Q=n1374
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG90_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n22 CK=CTS_2 Q=n1372
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG85_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n29 CK=CTS_2 Q=n1369
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG436_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<0> CK=CTS_5 Q=n1364
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG438_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<1> CK=CTS_5 Q=n1363
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG440_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<2> CK=CTS_5 Q=n1362
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG442_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<3> CK=CTS_5 Q=n1361
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG444_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<4> CK=CTS_5 Q=n1360
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG448_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<6> CK=CTS_5 Q=n1358
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG71_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n32 CK=CTS_1 Q=n1355
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG73_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n30 CK=CTS_1 Q=n1351
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG74_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n27 CK=CTS_5 Q=n1349
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG75_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n26 CK=CTS_5 Q=n1348
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG78_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n19 CK=CTS_5 Q=n1346
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG80_S3 DFFQX1TR $PINS D=n1356
+ CK=CTS_5 Q=n1345
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG424_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<2> CK=CTS_5 Q=n1342
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG426_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<3> CK=CTS_5 Q=n1341
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG430_S2 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<5> CK=CTS_5 Q=n1339
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG432_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<6> CK=CTS_5 Q=n1338
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG434_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<7> CK=CTS_5 Q=n1337
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG44_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n29 CK=CTS_7 Q=n1335
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG37_S3 DFFHQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n1 CK=CTS_7 Q=n1336
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG46_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n5 CK=CTS_7 Q=n1333
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG48_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n22 CK=CTS_5 Q=n1331
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG50_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n20 CK=CTS_5 Q=n1330
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG43_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n31 CK=CTS_7 Q=n1327
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG409_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<2> CK=CTS_5 Q=n1324
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG411_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<3> CK=CTS_5 Q=n1323
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG126_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<4> CK=CTS_5 Q=n1322
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG414_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<5> CK=CTS_5 Q=n1321
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG416_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<6> CK=CTS_5 Q=n1320
Xclk_r_REG35_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n28 CK=CTS_1
+ Q=n1770
Xclk_r_REG182_S2 DFFQX1TR $PINS D=n2270 CK=CTS_11 Q=n1755
Xclk_r_REG554_S1 DFFQX1TR $PINS D=n1704 CK=CTS_1 Q=n2209
Xclk_r_REG289_S1 DFFQX1TR $PINS D=n1635 CK=CTS_9 Q=n2133
Xclk_r_REG324_S1 DFFQX1TR $PINS D=n1684 CK=CTS_12 Q=n2187
Xclk_r_REG239_S1 DFFQX1TR $PINS D=n1615 CK=CTS_7 Q=n2111
Xclk_r_REG174_S1 DFFQX1TR $PINS D=n1520 CK=CTS_11 Q=n2004
Xclk_r_REG353_S1 DFFQX1TR $PINS D=n1656 CK=CTS_8 Q=n2156
Xclk_r_REG220_S1 DFFQX1TR $PINS D=n1548 CK=CTS_8 Q=n2036
Xclk_r_REG571_S1 DFFQX1TR $PINS D=n1711 CK=CTS_3 Q=n2216
Xclk_r_REG165_S1 DFFQX1TR $PINS D=n1511 CK=CTS_3 Q=n1995
Xclk_r_REG15_S3 DFFQX1TR $PINS D=n1399 CK=CTS_12 Q=n1807
Xclk_r_REG31_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<5> CK=CTS_12 Q=n1786
Xclk_r_REG30_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<4> CK=CTS_12 Q=n1785
Xclk_r_REG190_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<0> CK=CTS_3 Q=n1781
Xclk_r_REG367_S2 DFFQX1TR $PINS D=n2274 CK=CTS_11 Q=n1759
Xclk_r_REG347_S2 DFFQX1TR $PINS D=n2264 CK=CTS_6 Q=n1751
Xclk_r_REG213_S2 DFFQX1TR $PINS D=n2261 CK=CTS_6 Q=n1748
Xclk_r_REG348_S2 DFFQX1TR $PINS D=n2254 CK=CTS_2 Q=n1743
Xclk_r_REG304_S2 DFFQX1TR $PINS D=n2253 CK=CTS_1 Q=n1742
Xclk_r_REG481_S2 DFFQX1TR $PINS D=n2246 CK=CTS_1 Q=n1736
Xclk_r_REG329_S2 DFFQX1TR $PINS D=n2244 CK=CTS_1 Q=n1735
Xclk_r_REG285_S2 DFFQX1TR $PINS D=n2243 CK=CTS_7 Q=n1734
Xclk_r_REG241_S2 DFFQX1TR $PINS D=n2242 CK=CTS_7 Q=n1733
Xclk_r_REG194_S2 DFFQX1TR $PINS D=n2241 CK=CTS_7 Q=n1732
Xclk_r_REG506_S2 DFFQX1TR $PINS D=n2238 CK=CTS_7 Q=n1729
Xclk_r_REG372_S2 DFFQX1TR $PINS D=PE_top0_ST_ADD<2> CK=CTS_12 Q=n1820
Xclk_r_REG378_S2 DFFQX1TR $PINS D=PE_top0_ST_ADD<1> CK=CTS_12 Q=n1821
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG122_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n20 CK=CTS_11 Q=n1392
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG390_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<0> CK=CTS_11 Q=n1385
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG88_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n25 CK=CTS_2 Q=n1375
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG91_S3 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n23 CK=CTS_2 Q=n1373
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG87_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n30 CK=CTS_2 Q=n1370
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG93_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n19 CK=CTS_5 Q=n1366
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG79_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n20 CK=CTS_5 Q=n1352
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG77_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n23 CK=CTS_5 Q=n1347
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG420_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<0> CK=CTS_5 Q=n1344
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG428_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<4> CK=CTS_5 Q=n1340
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG45_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n30 CK=CTS_7 Q=n1334
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG47_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n23 CK=CTS_7 Q=n1332
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG51_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n19 CK=CTS_5 Q=n1329
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG49_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n2 CK=CTS_5 Q=n1328
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG405_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<0> CK=CTS_11 Q=n1326
Xclk_r_REG581_S1 DFFQX1TR $PINS D=n1721 CK=CTS_7 Q=n2226
Xclk_r_REG362_S1 DFFQX1TR $PINS D=n1665 CK=CTS_8 Q=n2165
Xclk_r_REG318_S1 DFFQX1TR $PINS D=n1629 CK=CTS_8 Q=n2125
Xclk_r_REG274_S1 DFFQX1TR $PINS D=n1593 CK=CTS_11 Q=n2085
Xclk_r_REG229_S1 DFFQX1TR $PINS D=n1557 CK=CTS_11 Q=n2045
Xclk_r_REG555_S1 DFFQX1TR $PINS D=n1705 CK=CTS_1 Q=n2210
Xclk_r_REG553_S1 DFFQX1TR $PINS D=n1703 CK=CTS_12 Q=n2208
Xclk_r_REG552_S1 DFFQX2TR $PINS D=n1702 CK=CTS_12 Q=n2207
Xclk_r_REG551_S1 DFFQX1TR $PINS D=n1701 CK=CTS_12 Q=n2206
Xclk_r_REG550_S1 DFFQX1TR $PINS D=n1700 CK=CTS_12 Q=n2205
Xclk_r_REG565_S1 DFFQX1TR $PINS D=n1695 CK=CTS_9 Q=n2200
Xclk_r_REG564_S1 DFFQX1TR $PINS D=n1694 CK=CTS_12 Q=n2199
Xclk_r_REG563_S1 DFFQX1TR $PINS D=n1693 CK=CTS_12 Q=n2198
Xclk_r_REG562_S1 DFFQX1TR $PINS D=n1692 CK=CTS_1 Q=n2197
Xclk_r_REG451_S1 DFFQX1TR $PINS D=n1690 CK=CTS_1 Q=n2194
Xclk_r_REG326_S1 DFFQX1TR $PINS D=n1686 CK=CTS_1 Q=n2189
Xclk_r_REG342_S1 DFFQX1TR $PINS D=n1680 CK=CTS_1 Q=n2182
Xclk_r_REG341_S1 DFFQX1TR $PINS D=n1679 CK=CTS_1 Q=n2181
Xclk_r_REG340_S1 DFFQX1TR $PINS D=n1678 CK=CTS_3 Q=n2180
Xclk_r_REG339_S1 DFFQX1TR $PINS D=n1677 CK=CTS_12 Q=n2179
Xclk_r_REG338_S1 DFFQX1TR $PINS D=n1676 CK=CTS_12 Q=n2178
Xclk_r_REG337_S1 DFFQX1TR $PINS D=n1675 CK=CTS_1 Q=n2177
Xclk_r_REG334_S1 DFFQX1TR $PINS D=n1672 CK=CTS_1 Q=n2174
Xclk_r_REG333_S1 DFFQX1TR $PINS D=n1671 CK=CTS_1 Q=n2173
Xclk_r_REG332_S1 DFFQX1TR $PINS D=n1670 CK=CTS_12 Q=n2172
Xclk_r_REG331_S1 DFFQX1TR $PINS D=n1669 CK=CTS_12 Q=n2171
Xclk_r_REG330_S1 DFFQX1TR $PINS D=n1668 CK=CTS_9 Q=n2170
Xclk_r_REG282_S1 DFFQX1TR $PINS D=n1650 CK=CTS_1 Q=n2149
Xclk_r_REG298_S1 DFFQX1TR $PINS D=n1644 CK=CTS_1 Q=n2142
Xclk_r_REG297_S1 DFFQX1TR $PINS D=n1643 CK=CTS_1 Q=n2141
Xclk_r_REG296_S1 DFFQX1TR $PINS D=n1642 CK=CTS_12 Q=n2140
Xclk_r_REG295_S1 DFFQX1TR $PINS D=n1641 CK=CTS_12 Q=n2139
Xclk_r_REG294_S1 DFFQX1TR $PINS D=n1640 CK=CTS_1 Q=n2138
Xclk_r_REG293_S1 DFFQX2TR $PINS D=n1639 CK=CTS_1 Q=n2137
Xclk_r_REG290_S1 DFFQX1TR $PINS D=n1636 CK=CTS_9 Q=n2134
Xclk_r_REG288_S1 DFFQX1TR $PINS D=n1634 CK=CTS_9 Q=n2132
Xclk_r_REG287_S1 DFFQX1TR $PINS D=n1633 CK=CTS_9 Q=n2131
Xclk_r_REG286_S1 DFFQX1TR $PINS D=n1632 CK=CTS_9 Q=n2130
Xclk_r_REG238_S1 DFFQX1TR $PINS D=n1614 CK=CTS_9 Q=n2109
Xclk_r_REG254_S1 DFFQX1TR $PINS D=n1608 CK=CTS_1 Q=n2102
Xclk_r_REG253_S1 DFFQX1TR $PINS D=n1607 CK=CTS_1 Q=n2101
Xclk_r_REG252_S1 DFFQX1TR $PINS D=n1606 CK=CTS_3 Q=n2100
Xclk_r_REG251_S1 DFFQX1TR $PINS D=n1605 CK=CTS_3 Q=n2099
Xclk_r_REG250_S1 DFFQX1TR $PINS D=n1604 CK=CTS_6 Q=n2098
Xclk_r_REG249_S1 DFFQX1TR $PINS D=n1603 CK=CTS_6 Q=n2097
Xclk_r_REG246_S1 DFFQX1TR $PINS D=n1600 CK=CTS_7 Q=n2094
Xclk_r_REG245_S1 DFFQX1TR $PINS D=n1599 CK=CTS_9 Q=n2093
Xclk_r_REG244_S1 DFFQX1TR $PINS D=n1598 CK=CTS_9 Q=n2092
Xclk_r_REG243_S1 DFFQX1TR $PINS D=n1597 CK=CTS_9 Q=n2091
Xclk_r_REG242_S1 DFFQX1TR $PINS D=n1596 CK=CTS_9 Q=n2090
Xclk_r_REG185_S1 DFFQX1TR $PINS D=n1578 CK=CTS_9 Q=n2069
Xclk_r_REG207_S1 DFFQX1TR $PINS D=n1572 CK=CTS_1 Q=n2062
Xclk_r_REG206_S1 DFFQX1TR $PINS D=n1571 CK=CTS_1 Q=n2061
Xclk_r_REG205_S1 DFFQX1TR $PINS D=n1570 CK=CTS_12 Q=n2060
Xclk_r_REG204_S1 DFFQX1TR $PINS D=n1569 CK=CTS_12 Q=n2059
Xclk_r_REG582_S1 DFFQX1TR $PINS D=n1722 CK=CTS_11 Q=n2227
Xclk_r_REG364_S1 DFFQX1TR $PINS D=n1667 CK=CTS_11 Q=n2169
Xclk_r_REG320_S1 DFFQX1TR $PINS D=n1631 CK=CTS_11 Q=n2129
Xclk_r_REG276_S1 DFFQX1TR $PINS D=n1595 CK=CTS_11 Q=n2089
Xclk_r_REG231_S1 DFFQX1TR $PINS D=n1559 CK=CTS_11 Q=n2049
Xclk_r_REG570_S1 DFFQX1TR $PINS D=n1723 CK=CTS_6 Q=n2228
Xclk_r_REG580_S1 DFFQX1TR $PINS D=n1720 CK=CTS_3 Q=n2225
Xclk_r_REG560_S1 DFFQX1TR $PINS D=n1710 CK=CTS_2 Q=n2215
Xclk_r_REG0_S1 DFFQX1TR $PINS D=n1689 CK=CTS_12 Q=n2193
Xclk_r_REG335_S1 DFFQX1TR $PINS D=n1673 CK=CTS_2 Q=n2175
Xclk_r_REG363_S1 DFFQX1TR $PINS D=n1666 CK=CTS_2 Q=n2167
Xclk_r_REG359_S1 DFFQX1TR $PINS D=n1662 CK=CTS_3 Q=n2162
Xclk_r_REG280_S1 DFFQX1TR $PINS D=n1648 CK=CTS_9 Q=n2147
Xclk_r_REG291_S1 DFFQX1TR $PINS D=n1637 CK=CTS_2 Q=n2135
Xclk_r_REG319_S1 DFFQX1TR $PINS D=n1630 CK=CTS_2 Q=n2127
Xclk_r_REG315_S1 DFFQX1TR $PINS D=n1626 CK=CTS_3 Q=n2122
Xclk_r_REG236_S1 DFFQX1TR $PINS D=n1612 CK=CTS_9 Q=n2107
Xclk_r_REG247_S1 DFFQX1TR $PINS D=n1601 CK=CTS_6 Q=n2095
Xclk_r_REG275_S1 DFFQX1TR $PINS D=n1594 CK=CTS_2 Q=n2087
Xclk_r_REG271_S1 DFFQX1TR $PINS D=n1590 CK=CTS_3 Q=n2082
Xclk_r_REG183_S1 DFFQX1TR $PINS D=n1576 CK=CTS_9 Q=n2067
Xclk_r_REG200_S1 DFFQX1TR $PINS D=n1565 CK=CTS_6 Q=n2055
Xclk_r_REG230_S1 DFFQX1TR $PINS D=n1558 CK=CTS_2 Q=n2047
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG81_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n13 CK=CTS_5 Q=n1354
Xclk_r_REG561_S1 DFFQX1TR $PINS D=n1691 CK=CTS_12 Q=n2196
Xclk_r_REG281_S1 DFFQX1TR $PINS D=n1649 CK=CTS_9 Q=n2148
Xclk_r_REG237_S1 DFFQX1TR $PINS D=n1613 CK=CTS_9 Q=n2108
Xclk_r_REG184_S1 DFFQX1TR $PINS D=n1577 CK=CTS_9 Q=n2068
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG72_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n29 CK=CTS_1 Q=n1350
Xclk_r_REG360_S1 DFFQX1TR $PINS D=n1663 CK=CTS_3 Q=n2163
Xclk_r_REG316_S1 DFFQX1TR $PINS D=n1627 CK=CTS_3 Q=n2123
Xclk_r_REG272_S1 DFFQX1TR $PINS D=n1591 CK=CTS_3 Q=n2083
Xclk_r_REG327_S1 DFFQX1TR $PINS D=n1687 CK=CTS_7 Q=n2191
Xclk_r_REG345_S1 DFFQX1TR $PINS D=n1683 CK=CTS_2 Q=n2186
Xclk_r_REG336_S1 DFFQX1TR $PINS D=n1674 CK=CTS_2 Q=n2176
Xclk_r_REG283_S1 DFFQX1TR $PINS D=n1651 CK=CTS_7 Q=n2151
Xclk_r_REG301_S1 DFFQX1TR $PINS D=n1647 CK=CTS_2 Q=n2146
Xclk_r_REG292_S1 DFFQX1TR $PINS D=n1638 CK=CTS_2 Q=n2136
Xclk_r_REG257_S1 DFFQX1TR $PINS D=n1611 CK=CTS_2 Q=n2106
Xclk_r_REG248_S1 DFFQX1TR $PINS D=n1602 CK=CTS_2 Q=n2096
Xclk_r_REG186_S1 DFFQX1TR $PINS D=n1579 CK=CTS_7 Q=n2071
Xclk_r_REG210_S1 DFFQX1TR $PINS D=n1575 CK=CTS_2 Q=n2066
Xclk_r_REG201_S1 DFFQX1TR $PINS D=n1566 CK=CTS_2 Q=n2056
Xclk_r_REG42_S1 DFFHQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n2 CK=CTS_1
+ Q=n1765
Xclk_r_REG36_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n27 CK=CTS_1
+ Q=n1769
Xclk_r_REG388_S1 DFFQX1TR $PINS D=n1688 CK=CTS_9 Q=n2192
Xclk_r_REG361_S1 DFFQX1TR $PINS D=n1664 CK=CTS_8 Q=n2164
Xclk_r_REG317_S1 DFFQX1TR $PINS D=n1628 CK=CTS_8 Q=n2124
Xclk_r_REG273_S1 DFFQX1TR $PINS D=n1592 CK=CTS_8 Q=n2084
Xclk_r_REG228_S1 DFFQX1TR $PINS D=n1556 CK=CTS_8 Q=n2044
Xclk_r_REG356_S1 DFFQX1TR $PINS D=n1659 CK=CTS_8 Q=n2159
Xclk_r_REG312_S1 DFFQX1TR $PINS D=n1623 CK=CTS_8 Q=n2119
Xclk_r_REG268_S1 DFFQX1TR $PINS D=n1587 CK=CTS_8 Q=n2079
Xclk_r_REG223_S1 DFFQX1TR $PINS D=n1551 CK=CTS_8 Q=n2039
Xclk_r_REG169_S1 DFFQX1TR $PINS D=n1515 CK=CTS_8 Q=n1999
Xclk_r_REG579_S1 DFFQX1TR $PINS D=n1719 CK=CTS_8 Q=n2224
Xclk_r_REG578_S1 DFFQX1TR $PINS D=n1718 CK=CTS_9 Q=n2223
Xclk_r_REG576_S1 DFFQX1TR $PINS D=n1716 CK=CTS_9 Q=n2221
Xclk_r_REG575_S1 DFFQX1TR $PINS D=n1715 CK=CTS_9 Q=n2220
Xclk_r_REG574_S1 DFFQX1TR $PINS D=n1714 CK=CTS_9 Q=n2219
Xclk_r_REG358_S1 DFFQX1TR $PINS D=n1661 CK=CTS_8 Q=n2161
Xclk_r_REG357_S1 DFFQX1TR $PINS D=n1660 CK=CTS_8 Q=n2160
Xclk_r_REG355_S1 DFFQX1TR $PINS D=n1658 CK=CTS_8 Q=n2158
Xclk_r_REG354_S1 DFFQX1TR $PINS D=n1657 CK=CTS_8 Q=n2157
Xclk_r_REG314_S1 DFFQX1TR $PINS D=n1625 CK=CTS_8 Q=n2121
Xclk_r_REG313_S1 DFFQX1TR $PINS D=n1624 CK=CTS_8 Q=n2120
Xclk_r_REG311_S1 DFFQX1TR $PINS D=n1622 CK=CTS_8 Q=n2118
Xclk_r_REG310_S1 DFFQX1TR $PINS D=n1621 CK=CTS_8 Q=n2117
Xclk_r_REG309_S1 DFFQX1TR $PINS D=n1620 CK=CTS_8 Q=n2116
Xclk_r_REG270_S1 DFFQX1TR $PINS D=n1589 CK=CTS_8 Q=n2081
Xclk_r_REG269_S1 DFFQX1TR $PINS D=n1588 CK=CTS_8 Q=n2080
Xclk_r_REG267_S1 DFFQX1TR $PINS D=n1586 CK=CTS_8 Q=n2078
Xclk_r_REG266_S1 DFFQX1TR $PINS D=n1585 CK=CTS_8 Q=n2077
Xclk_r_REG265_S1 DFFQX1TR $PINS D=n1584 CK=CTS_8 Q=n2076
Xclk_r_REG225_S1 DFFQX1TR $PINS D=n1553 CK=CTS_8 Q=n2041
Xclk_r_REG224_S1 DFFQX1TR $PINS D=n1552 CK=CTS_8 Q=n2040
Xclk_r_REG222_S1 DFFQX1TR $PINS D=n1550 CK=CTS_8 Q=n2038
Xclk_r_REG221_S1 DFFQX1TR $PINS D=n1549 CK=CTS_8 Q=n2037
Xclk_r_REG171_S1 DFFQX1TR $PINS D=n1517 CK=CTS_8 Q=n2001
Xclk_r_REG170_S1 DFFQX1TR $PINS D=n1516 CK=CTS_8 Q=n2000
Xclk_r_REG535_S1 DFFQX1TR $PINS D=n1445 CK=CTS_8 Q=n1921
Xclk_r_REG534_S1 DFFQX1TR $PINS D=n1444 CK=CTS_8 Q=n1920
Xclk_r_REG532_S1 DFFQX1TR $PINS D=n1442 CK=CTS_8 Q=n1918
Xclk_r_REG531_S1 DFFQX1TR $PINS D=n1441 CK=CTS_8 Q=n1917
Xclk_r_REG530_S1 DFFQX1TR $PINS D=n1440 CK=CTS_8 Q=n1916
Xclk_r_REG491_S1 DFFQX1TR $PINS D=n1409 CK=CTS_8 Q=n1881
Xclk_r_REG490_S1 DFFQX1TR $PINS D=n1408 CK=CTS_8 Q=n1880
Xclk_r_REG488_S1 DFFQX1TR $PINS D=n1406 CK=CTS_8 Q=n1878
Xclk_r_REG487_S1 DFFQX1TR $PINS D=n1405 CK=CTS_8 Q=n1877
Xclk_r_REG486_S1 DFFQX1TR $PINS D=n1404 CK=CTS_8 Q=n1876
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG418_S2 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<7> CK=CTS_5 Q=n1319
Xclk_r_REG573_S1 DFFQX1TR $PINS D=n1713 CK=CTS_3 Q=n2218
Xclk_r_REG558_S1 DFFQX1TR $PINS D=n1708 CK=CTS_3 Q=n2213
Xclk_r_REG557_S1 DFFQX1TR $PINS D=n1707 CK=CTS_6 Q=n2212
Xclk_r_REG352_S1 DFFQX1TR $PINS D=n1655 CK=CTS_3 Q=n2155
Xclk_r_REG351_S1 DFFQX1TR $PINS D=n1654 CK=CTS_3 Q=n2154
Xclk_r_REG350_S1 DFFQX1TR $PINS D=n1653 CK=CTS_3 Q=n2153
Xclk_r_REG308_S1 DFFQX1TR $PINS D=n1619 CK=CTS_3 Q=n2115
Xclk_r_REG307_S1 DFFQX1TR $PINS D=n1618 CK=CTS_3 Q=n2114
Xclk_r_REG306_S1 DFFQX1TR $PINS D=n1617 CK=CTS_3 Q=n2113
Xclk_r_REG264_S1 DFFQX1TR $PINS D=n1583 CK=CTS_3 Q=n2075
Xclk_r_REG263_S1 DFFQX1TR $PINS D=n1582 CK=CTS_3 Q=n2074
Xclk_r_REG262_S1 DFFQX1TR $PINS D=n1581 CK=CTS_6 Q=n2073
Xclk_r_REG219_S1 DFFQX1TR $PINS D=n1547 CK=CTS_3 Q=n2035
Xclk_r_REG218_S1 DFFQX1TR $PINS D=n1546 CK=CTS_3 Q=n2034
Xclk_r_REG217_S1 DFFQX1TR $PINS D=n1545 CK=CTS_6 Q=n2033
Xclk_r_REG164_S1 DFFQX1TR $PINS D=n1510 CK=CTS_3 Q=n1994
Xclk_r_REG163_S1 DFFQX1TR $PINS D=n1509 CK=CTS_6 Q=n1993
Xclk_r_REG98_S1 DFFQX1TR $PINS D=n1474 CK=CTS_3 Q=n1954
Xclk_r_REG521_S1 DFFQX1TR $PINS D=n1466 CK=CTS_6 Q=n1944
Xclk_r_REG529_S1 DFFQX1TR $PINS D=n1439 CK=CTS_3 Q=n1915
Xclk_r_REG528_S1 DFFQX1TR $PINS D=n1438 CK=CTS_3 Q=n1914
Xclk_r_REG527_S1 DFFQX1TR $PINS D=n1437 CK=CTS_6 Q=n1913
Xclk_r_REG477_S1 DFFQX1TR $PINS D=n1430 CK=CTS_6 Q=n1904
Xclk_r_REG485_S1 DFFQX1TR $PINS D=n1403 CK=CTS_3 Q=n1875
Xclk_r_REG484_S1 DFFQX1TR $PINS D=n1402 CK=CTS_3 Q=n1874
Xclk_r_REG483_S1 DFFQX1TR $PINS D=n1401 CK=CTS_6 Q=n1873
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG114_S3 DFFHQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n31 CK=CTS_7 Q=n1386
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG456_S2 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<7> CK=CTS_5 Q=n1357
Xclk_r_REG365_S2 DFFQX1TR $PINS D=n2169 CK=CTS_11 Q=n2168
Xclk_r_REG187_S2 DFFQX1TR $PINS D=n2071 CK=CTS_7 Q=n2070
Xclk_r_REG138_S2 DFFQX1TR $PINS D=n2031 CK=CTS_7 Q=n2030
Xclk_r_REG366_S2 DFFQX1TR $PINS D=n2167 CK=CTS_2 Q=n2166
Xclk_r_REG346_S2 DFFQX1TR $PINS D=n2186 CK=CTS_2 Q=n2185
Xclk_r_REG328_S2 DFFQX1TR $PINS D=n2191 CK=CTS_7 Q=n2190
Xclk_r_REG284_S2 DFFQX1TR $PINS D=n2151 CK=CTS_7 Q=n2150
Xclk_r_REG302_S2 DFFQX1TR $PINS D=n2146 CK=CTS_2 Q=n2145
Xclk_r_REG322_S2 DFFQX1TR $PINS D=n2127 CK=CTS_2 Q=n2126
Xclk_r_REG499_S2 DFFQX1TR $PINS D=n1887 CK=CTS_2 Q=n1886
Xclk_r_REG234_S2 DFFQX1TR $PINS D=n2047 CK=CTS_2 Q=n2046
Xclk_r_REG278_S2 DFFQX1TR $PINS D=n2087 CK=CTS_2 Q=n2086
Xclk_r_REG211_S2 DFFQX1TR $PINS D=n2066 CK=CTS_2 Q=n2065
Xclk_r_REG156_S2 DFFQX1TR $PINS D=n2026 CK=CTS_1 Q=n2025
Xclk_r_REG240_S2 DFFQX1TR $PINS D=n2111 CK=CTS_7 Q=n2110
Xclk_r_REG461_S2 DFFQX1TR $PINS D=n1911 CK=CTS_7 Q=n1910
Xclk_r_REG505_S2 DFFQX1TR $PINS D=n1951 CK=CTS_7 Q=n1950
Xclk_r_REG69_S2 DFFQX1TR $PINS D=n1986 CK=CTS_2 Q=n1985
Xclk_r_REG479_S2 DFFQX1TR $PINS D=n1906 CK=CTS_2 Q=n1905
Xclk_r_REG10_S3 DFFQX1TR $PINS D=n1724 CK=CTS_12 Q=n2229
Xclk_r_REG542_S2 DFFQX1TR $PINS D=n1929 CK=CTS_11 Q=n1928
Xclk_r_REG8_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<2> CK=CTS_12 Q=n1783
XPE_top0_buff_mult_arr0_mult_x_24_R_2_clk_r_REG113_S3 DFFQX1TR $PINS D=n119
+ CK=CTS_7 Q=n22
XPE_top0_buff_mult_arr0_mult_x_24_R_3_clk_r_REG118_S3 DFFQX1TR $PINS D=n368
+ CK=CTS_7 Q=n21
XPE_top0_buff_mult_arr0_mult_x_24_R_4_clk_r_REG118_S3 DFFQX1TR $PINS D=n591
+ CK=CTS_7 Q=n20
Xclk_r_REG543_S2 DFFQX1TR $PINS D=n1927 CK=CTS_2 Q=n1926
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG407_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<1> CK=CTS_5 Q=n1325
Xclk_r_REG27_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<3> CK=CTS_12 Q=n1784
Xclk_r_REG277_S2 DFFQX1TR $PINS D=n2089 CK=CTS_11 Q=n2088
Xclk_r_REG178_S2 DFFQX1TR $PINS D=n2009 CK=CTS_11 Q=n2008
Xclk_r_REG70_S3 DFFHQX8TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<5>
+ CK=CTS_1 Q=n1862
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG94_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n2 CK=CTS_5 Q=n1365
Xclk_r_REG540_S1 DFFQX1TR $PINS D=n1450 CK=CTS_2 Q=n1927
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG422_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<1> CK=CTS_5 Q=n1343
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG398_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<4> CK=CTS_11 Q=n1381
Xclk_r_REG258_S2 DFFQX1TR $PINS D=n2106 CK=CTS_2 Q=n2105
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG86_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n24 CK=CTS_2 Q=n1371
Xclk_r_REG24_S3 DFFQX1TR $PINS D=n1725 CK=CTS_12 Q=n2230
Xclk_r_REG480_S2 DFFQX1TR $PINS D=n2256 CK=CTS_6 Q=n1744
Xclk_r_REG161_S2 DFFQX1TR $PINS D=n2250 CK=CTS_1 Q=n1739
Xclk_r_REG523_S2 DFFQX1TR $PINS D=n1946 CK=CTS_2 Q=n1945
Xclk_r_REG525_S2 DFFQX1TR $PINS D=n2248 CK=CTS_1 Q=n1737
Xclk_r_REG544_S2 DFFQX1TR $PINS D=n2268 CK=CTS_11 Q=n1753
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG92_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n20 CK=CTS_5 Q=n1367
XPE_top0_buff_mult_arr0_mult_x_24_R_1_clk_r_REG113_S3 DFFQX1TR $PINS D=n593
+ CK=CTS_7 Q=n23
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG119_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n23 CK=CTS_7 Q=n1389
XPE_top0_buff_mult_arr0_mult_x_24_R_0_clk_r_REG113_S3 DFFQX1TR $PINS D=n122
+ CK=CTS_7 Q=n24
XPE_top0_buff_mult_arr0_mult_x_24_R_5_clk_r_REG123_S3 DFFQX1TR $PINS D=n831
+ CK=CTS_11 Q=n19
XPE_top0_buff_mult_arr0_mult_x_24_R_6_clk_r_REG123_S3 DFFQX1TR $PINS D=n51
+ CK=CTS_11 Q=n18
Xclk_r_REG21_S3 DFFQX1TR $PINS D=n1398 CK=CTS_12 Q=n1806
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG89_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n5 CK=CTS_2 Q=n1368
Xclk_r_REG38_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n25 CK=CTS_7
+ Q=n1768
Xclk_r_REG6_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<5>
+ CK=CTS_7 Q=n1860
Xclk_r_REG128_S1 DFFQX1TR $PINS D=PE_top0_adder0_out_int2<1> CK=CTS_12 Q=n1775
XU48 AO22X1TR $PINS A0=n923 A1=FE_OFN35_n949 B0=FE_OFN56_n923 B1=n1939 Y=n1461
XU49 NAND2X1TR $PINS A=n706 B=n707 Y=PE_top0_buff_mult_arr0_mult_x_30_n20
XU50 NOR2X1TR $PINS A=n1113 B=n1112 Y=PE_top0_DP_OP_17J1_122_4844_n34
XU52 XOR2X1TR $PINS A=n52 B=n823 Y=n51
XU53 OAI2BB2XLTR $PINS A0N=n616 A1N=n2229 B0=n1055 B1=n616 Y=n1724
XU55 INVX2TR $PINS A=n882 Y=n1017
XU57 INVX4TR $PINS A=n911 Y=n990
XU59 INVX4TR $PINS A=n925 Y=n1009
XU65 NAND2X1TR $PINS A=n780 B=n779 Y=PE_top0_buff_mult_arr0_mult_x_27_n30
XU66 INVX2TR $PINS A=n794 Y=n796
XU67 AND2X2TR $PINS A=n736 B=n735 Y=n7
XU68 OAI2BB2XLTR $PINS A0N=n606 A1N=n662 B0=n608 B1=n607 Y=n658
XU69 INVX2TR $PINS A=n739 Y=n108
XU70 NAND2X1TR $PINS A=n774 B=n773 Y=n775
XU71 NAND2X1TR $PINS A=n92 B=n368 Y=n91
XU72 OR2X4TR $PINS A=n367 B=n366 Y=n368
XU74 OR2X4TR $PINS A=n474 B=n473 Y=n785
XU76 INVX2TR $PINS A=n704 Y=n732
XU77 CLKINVX2TR $PINS A=PE_top0_buff_mult_arr0_mult_x_24_n30 Y=n92
XU78 NAND2BX1TR $PINS AN=n824 B=n55 Y=n834
XU83 INVX2TR $PINS A=n735 Y=n700
XU84 INVX2TR $PINS A=n1116 Y=n284
XU85 NOR2X1TR $PINS A=n80 B=FE_OFN117_n Y=pe_out_pk_data__6_
XU86 NAND2BX1TR $PINS AN=n661 B=n608 Y=n606
XU87 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__7_ B=FE_OFN8_reset Y=n881
XU88 NOR2X1TR $PINS A=n64 B=FE_OFN117_n Y=pe_out_pk_data__4_
XU92 XOR2X1TR $PINS A=n810 B=n54 Y=n53
XU102 OR2X2TR $PINS A=n316 B=n315 Y=n643
XU103 OR2X4TR $PINS A=n329 B=n330 Y=n432
XU107 INVX2TR $PINS A=n373 Y=n405
XU110 INVX2TR $PINS A=n642 Y=n431
XU111 CLKINVX2TR $PINS A=n62 Y=n60
XU113 INVX2TR $PINS A=n1126 Y=n472
XU114 OAI22X1TR $PINS A0=n721 A1=n263 B0=n719 B1=n574 Y=n580
XU115 OAI21X1TR $PINS A0=n885 A1=FE_OCPN143_n879 B0=FE_OFN115_n Y=n880
XU116 OAI21X2TR $PINS A0=n902 A1=n924 B0=FE_OFN116_n Y=n889
XU117 OAI21X2TR $PINS A0=n929 A1=FE_OCPN143_n879 B0=FE_OFN115_n Y=n930
XU118 OR2X4TR $PINS A=n403 B=n402 Y=n841
XU119 OAI21X1TR $PINS A0=n895 A1=FE_OCPN143_n879 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n896
XU120 OAI21X1TR $PINS A0=n946 A1=n879 B0=FE_DBTN1_reset Y=n906
XU121 OR2X4TR $PINS A=n86 B=n85 Y=n735
XU122 NOR2BX1TR $PINS AN=n563 B=FE_DBTN0_n2195 Y=n564
XU123 OAI21X1TR $PINS A0=n922 A1=FE_PSBN144_n915 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n923
XU124 OAI21X1TR $PINS A0=n946 A1=FE_PSBN144_n915 B0=FE_DBTN1_reset Y=n935
XU126 XNOR2X1TR $PINS A=n65 B=n72 Y=n64
XU127 OAI21X1TR $PINS A0=n902 A1=n929 B0=FE_OFN116_n Y=n890
XU128 OAI21X1TR $PINS A0=n902 A1=n932 B0=FE_OFN27_FE_DBTN1_reset Y=n891
XU129 OAI21X1TR $PINS A0=n902 A1=n885 B0=FE_OFN27_FE_DBTN1_reset Y=n886
XU130 OAI21X1TR $PINS A0=n902 A1=n920 B0=FE_OFN27_FE_DBTN1_reset Y=n887
XU132 AO21X1TR $PINS A0=n760 A1=n169 B0=n758 Y=n761
XU133 OR2X4TR $PINS A=n695 B=n694 Y=n1132
XU135 CLKAND2X2TR $PINS A=n67 B=n1121 Y=n480
XU136 NOR2X1TR $PINS A=n1769 B=n1767 Y=n1156
XU137 INVX2TR $PINS A=n461 Y=n464
XU138 OAI22X1TR $PINS A0=n147 A1=n249 B0=n144 B1=n50 Y=n423
XU139 OR3X2TR $PINS A=n893 B=n892 C=pe_in_pk_wrb_addr__2_ Y=n924
XU140 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=n893 C=n892 Y=n922
XU142 NOR3X1TR $PINS A=FE_OFN71_pe_in_pk_rdb_addr__0 B=n1078 C=n1077 Y=n1100
XU143 NOR2BX1TR $PINS AN=n1779 B=FE_OFN112_reset Y=n287
XU144 ADDFHX2TR $PINS A=n205 B=n204 CI=n203 S=n355 CO=n837
XU145 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=pe_in_pk_wrb_addr__1_ C=n893
+ Y=n885
XU146 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__1_ B=n894 C=n893 Y=n929
XU148 ADDFHX2TR $PINS A=n442 B=n441 CI=n440 S=n476 CO=n779
XU149 INVX4TR $PINS A=n15 Y=n180
XU150 NOR2BX1TR $PINS AN=FE_OCPN141_n162 B=n746 Y=n181
XU151 NAND2X1TR $PINS A=n298 B=n297 Y=n302
XU152 NAND2X1TR $PINS A=n682 B=n681 Y=n686
XU153 OAI22X1TR $PINS A0=n760 A1=n184 B0=n169 B1=n412 Y=n409
XU154 OAI22X2TR $PINS A0=n386 A1=n374 B0=n369 B1=n384 Y=n588
XU155 OAI22X1TR $PINS A0=n197 A1=n202 B0=n195 B1=n206 Y=n203
XU156 OAI22X1TR $PINS A0=n748 A1=n413 B0=n746 B1=n747 Y=n766
XU157 OAI22X1TR $PINS A0=n760 A1=n412 B0=n169 B1=n751 Y=n767
XU159 OAI22X1TR $PINS A0=n259 A1=n260 B0=n257 B1=n577 Y=n572
XU160 NAND2X1TR $PINS A=n401 B=n400 Y=n1121
XU162 XNOR2X1TR $PINS A=n1382 B=n799 Y=n807
XU163 XNOR2X1TR $PINS A=n576 B=n1343 Y=n265
XU164 ADDHX1TR $PINS A=n223 B=n222 S=n279 CO=n353
XU165 ADDHX1TR $PINS A=n314 B=n313 S=n304 CO=n315
XU166 NOR2BX1TR $PINS AN=n191 B=n819 Y=n365
XU167 CLKINVX2TR $PINS A=n452 Y=n13
XU169 NOR2BX1TR $PINS AN=n266 B=n257 Y=n683
XU171 OAI22X2TR $PINS A0=n757 A1=n168 B0=FE_OCPN142_n157 B1=n167 Y=n173
XU172 XNOR2X1TR $PINS A=n1382 B=n802 Y=n206
XU173 XNOR2X1TR $PINS A=n1380 B=n814 Y=n208
XU174 XNOR2X1TR $PINS A=n1359 B=n160 Y=n183
XU176 INVX2TR $PINS A=pe_in_pk_rdb_addr__1_ Y=n1077
XU179 NAND2X1TR $PINS A=n392 B=n391 Y=n393
XU180 NAND2BX1TR $PINS AN=n266 B=n1341 Y=n692
XU183 XNOR2X1TR $PINS A=n1357 B=FE_OCPN141_n162 Y=n176
XU184 XNOR2X1TR $PINS A=n1325 B=n307 Y=n319
XU187 XNOR2X1TR $PINS A=n1323 B=n140 Y=n321
XU189 XNOR2X1TR $PINS A=n1339 B=n266 Y=n596
XU190 XNOR2X1TR $PINS A=n1341 B=n663 Y=n603
XU191 XNOR2X1TR $PINS A=n385 B=n1380 Y=n359
XU192 XNOR2X1TR $PINS A=n1380 B=n191 Y=n360
XU193 XNOR2X1TR $PINS A=n1323 B=n132 Y=n291
XU195 XOR2X1TR $PINS A=n1381 B=n1380 Y=n201
XU197 NAND2X2TR $PINS A=n127 B=n125 Y=n716
XU198 INVX4TR $PINS A=n255 Y=n719
XU199 NOR2BX1TR $PINS AN=n191 B=n195 Y=n391
XU200 NAND2X1TR $PINS A=n1343 B=n677 Y=n264
XU201 OAI22X1TR $PINS A0=n386 A1=n385 B0=n383 B1=n384 Y=n392
XU202 AO22X2TR $PINS A0=n1762 A1=n1750 B0=n1868 B1=n2126 Y=n159
XU203 NOR2X1TR $PINS A=n1058 B=n1060 Y=n79
XU204 XNOR2X1TR $PINS A=n1325 B=n310 Y=n294
XU205 AO22X2TR $PINS A0=n1762 A1=n1749 B0=n1868 B1=n2086 Y=n160
XU206 XNOR2X1TR $PINS A=n1363 B=n743 Y=n171
XU207 NAND2X2TR $PINS A=n258 B=n257 Y=n259
XU209 INVX2TR $PINS A=n1364 Y=n454
XU210 INVX4TR $PINS A=n1326 Y=n317
XU211 NAND2BX1TR $PINS AN=n191 B=n1382 Y=n398
XU215 INVX2TR $PINS A=n1763 Y=n126
XU216 NAND2X2TR $PINS A=n1384 B=n384 Y=n386
XU224 XOR2X1TR $PINS A=n551 B=n349 Y=n350
XU225 XNOR2X1TR $PINS A=n1323 B=n133 Y=n312
XU226 XNOR2X1TR $PINS A=n1321 B=n132 Y=n148
XU227 XNOR2X1TR $PINS A=n561 B=PE_top0_buff_mult_arr0_mult_x_24_n5 Y=n563
XU228 NAND2X1TR $PINS A=n390 B=n389 Y=n394
XU230 INVX1TR $PINS A=n1771 Y=n1145
XU231 NOR2X1TR $PINS A=n1771 B=n1773 Y=n850
XU232 NAND2X1TR $PINS A=n1786 B=n2231 Y=n1067
XU233 NOR2BX1TR $PINS AN=n1778 B=FE_OFN112_reset Y=n286
XU234 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__6_ B=FE_OFN8_reset Y=n949
XU236 ADDFHX2TR $PINS A=n789 B=n788 CI=n787 S=n790 CO=n797
XU239 INVX2TR $PINS A=n781 Y=n786
XU241 INVX2TR $PINS A=n10 Y=n888
XU243 INVX2TR $PINS A=n933 Y=n1030
XU244 AO22X1TR $PINS A0=n910 A1=FE_OFN34_n881 B0=n988 B1=n1891 Y=n1417
XU245 AO22X1TR $PINS A0=n923 A1=FE_OFN34_n881 B0=FE_OFN56_n923 B1=n1899 Y=n1425
XU246 AO22X1TR $PINS A0=n910 A1=FE_OFN73_n949 B0=n988 B1=n1931 Y=n1453
XU247 AO22X1TR $PINS A0=n910 A1=FE_OFN93_n955 B0=n988 B1=n1971 Y=n1489
XU248 AO22X1TR $PINS A0=n923 A1=FE_OFN37_n955 B0=FE_OFN56_n923 B1=n1979 Y=n1497
XU249 AO22X1TR $PINS A0=n910 A1=FE_OFN85_n959 B0=n988 B1=n2011 Y=n1525
XU250 AO22X1TR $PINS A0=n923 A1=FE_OFN40_n959 B0=FE_OFN56_n923 B1=n2019 Y=n1533
XU251 AO22X1TR $PINS A0=n910 A1=FE_OFN87_n963 B0=n988 B1=n2051 Y=n1561
XU253 INVX2TR $PINS A=n593 Y=PE_top0_buff_mult_arr0_mult_x_24_n31
XU255 CLKINVX2TR $PINS A=n660 Y=n608
XU256 INVX2TR $PINS A=n930 Y=n1028
XU257 INVX2TR $PINS A=FE_PSN235_n880 Y=n1015
XU261 INVX1TR $PINS A=n1767 Y=n1152
XU263 INVX2TR $PINS A=n480 Y=n843
XU264 OR2X2TR $PINS A=n405 B=n404 Y=n844
XU265 OR2X4TR $PINS A=n376 B=n373 Y=n845
XU266 NAND2X1TR $PINS A=n68 B=n393 Y=n1123
XU267 INVX1TR $PINS A=n1117 Y=n289
XU270 NAND2X1TR $PINS A=n300 B=n299 Y=n301
XU273 INVX4TR $PINS A=n200 Y=n812
XU274 INVX1TR $PINS A=n1380 Y=n362
XU275 INVX1TR $PINS A=n1156 Y=n1159
XU276 INVX1TR $PINS A=n1157 Y=n1158
XU277 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__0_ B=pe_in_pk_wrb_addr__2_ C=n892
+ Y=n920
XU279 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__0_ B=n894 C=n892 Y=n932
XU282 CLKINVX4TR $PINS A=n1385 Y=n384
XU283 INVX1TR $PINS A=n1760 Y=n1144
XU284 INVX1TR $PINS A=n1769 Y=n1149
XU286 NOR2BX1TR $PINS AN=n564 B=FE_OFN9_reset Y=n619
XU287 XNOR2X1TR $PINS A=n1359 B=n752 Y=n754
XU288 OAI22X1TR $PINS A0=n806 A1=n208 B0=n812 B1=n813 Y=n830
XU289 INVX2TR $PINS A=pe_in_pk_wrb_addr__1_ Y=n892
XU290 AND2X2TR $PINS A=n1135 B=FE_DBTN1_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out1_0_
XU291 OAI2BB1X2TR $PINS A0N=n1137 A1N=n1138 B0=n1136 Y=n5
XU292 INVX2TR $PINS A=n5 Y=n434
XU293 NAND2X1TR $PINS A=n304 B=n303 Y=n1136
XU294 NOR2X1TR $PINS A=n797 B=n798 Y=PE_top0_buff_mult_arr0_mult_x_27_n19
XU295 XOR2X1TR $PINS A=n1362 B=n1361 Y=n170
XU297 XNOR2X1TR $PINS A=n1129 B=n1128 Y=n1130
XU298 OAI22X1TR $PINS A0=n760 A1=n172 B0=n169 B1=n184 Y=n179
XU299 XNOR2X1TR $PINS A=n737 B=n7
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<5>
XU300 NAND2X1TR $PINS A=n1869 B=n1905 Y=n124
XU302 XNOR2X4TR $PINS A=n727 B=n9 Y=n739
XU303 XNOR2X4TR $PINS A=n728 B=n109 Y=n9
XU304 XNOR2X1TR $PINS A=n1323 B=n310 Y=n323
XU305 OAI22X1TR $PINS A0=n197 A1=n206 B0=n195 B1=n801 Y=n824
XU306 NOR2X1TR $PINS A=n647 B=n646 Y=PE_top0_buff_mult_arr0_mult_x_33_n19
XU307 OAI21X2TR $PINS A0=n902 A1=n895 B0=FE_OFN32_FE_DBTN1_reset Y=n903
XU308 XNOR2X1TR $PINS A=n1325 B=n225 Y=n318
XU309 NOR2BX1TR $PINS AN=n530 B=n1865 Y=n531
XU310 XNOR2X1TR $PINS A=n1363 B=n740 Y=n449
XU311 AND2X2TR $PINS A=n351 B=FE_DBTN1_reset Y=n568
XU313 AO21X1TR $PINS A0=n139 A1=n137 B0=n232 Y=n233
XU314 NAND2X1TR $PINS A=n796 B=n795 Y=PE_top0_buff_mult_arr0_mult_x_27_n5
XU315 NAND2X1TR $PINS A=n432 B=n429 Y=n331
XU317 NOR2X4TR $PINS A=n189 B=n188 Y=n794
XU318 OA21X2TR $PINS A0=n902 A1=n922 B0=FE_OFN116_n Y=n10
XU319 XNOR2X1TR $PINS A=n1378 B=n814 Y=n820
XU320 NOR2X1TR $PINS A=n11 B=FE_OFN0_FE_DBTN0_n2195 Y=n535
XU321 XNOR2X1TR $PINS A=n534 B=n533 Y=n11
XU322 NOR2X2TR $PINS A=n118 B=n117 Y=n116
XU323 NOR2X1TR $PINS A=n744 B=FE_OCPN142_n157 Y=n118
XU324 NOR2BX1TR $PINS AN=n12 B=n87 Y=n536
XU325 XNOR2X1TR $PINS A=n89 B=n88 Y=n12
XU326 AND2X2TR $PINS A=n273 B=n73 Y=n578
XU327 NAND2X1TR $PINS A=n272 B=n271 Y=n273
XU328 NAND2X1TR $PINS A=n649 B=n648 Y=PE_top0_buff_mult_arr0_mult_x_30_n23
XU329 XOR2X1TR $PINS A=n332 B=n331
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<5>
XU330 AO21X1TR $PINS A0=n264 A1=n677 B0=n265 Y=n579
XU331 XOR2X1TR $PINS A=n253 B=n94 Y=PE_top0_buff_mult_arr0_mult_x_33_n2
XU333 NOR2X1TR $PINS A=n659 B=n658 Y=PE_top0_buff_mult_arr0_mult_x_30_n29
XU335 NOR2X1TR $PINS A=n791 B=n420 Y=PE_top0_buff_mult_arr0_mult_x_27_n22
XU336 ADDFHX2TR $PINS A=n789 B=n788 CI=n787 S=n420
XU337 OAI2BB2XLTR $PINS A0N=n13 A1N=n1364 B0=n453 B1=n159 Y=n461
XU338 NOR2X1TR $PINS A=n416 B=n757 Y=n117
XU339 XOR2X1TR $PINS A=n1320 B=n1319 Y=n130
XU341 OA22X2TR $PINS A0=n320 A1=n133 B0=n294 B1=n317 Y=n14
XU342 INVX2TR $PINS A=n14 Y=n300
XU343 INVX2TR $PINS A=n171 Y=n17
XU344 AOI2BB2X2TR $PINS A0N=n182 A1N=n454 B0=n16 B1=n17 Y=n15
XU345 INVX2TR $PINS A=n453 Y=n16
XU346 OAI21X1TR $PINS A0=n525 A1=n499 B0=n498 Y=n500
XU347 AO22X1TR $PINS A0=n878 A1=n877 B0=n616 B1=n1807 Y=n1399
XU348 AO22X1TR $PINS A0=n878 A1=n41 B0=n616 B1=n1806 Y=n1398
XU349 NOR2X2TR $PINS A=n751 B=n760 Y=n47
XU350 NOR2BX1TR $PINS AN=n522 B=FE_OFN9_reset Y=n860
XU351 XNOR2X1TR $PINS A=n484 B=PE_top0_buff_mult_arr0_mult_x_24_n2 Y=n485
XU352 NAND2X1TR $PINS A=n21 B=n20 Y=PE_top0_buff_mult_arr0_mult_x_24_n5
XU353 XOR2X1TR $PINS A=PE_top0_buff_mult_arr0_mult_x_24_n1 B=n541 Y=n542
XU354 OAI21X1TR $PINS A0=PE_top0_buff_mult_arr0_mult_x_24_n1 A1=n1388 B0=n1389
+ Y=n520
XU355 OAI21X1TR $PINS A0=PE_top0_buff_mult_arr0_mult_x_24_n1 A1=n483 B0=n482
+ Y=n484
XU356 NAND2X1TR $PINS A=n91 B=n591 Y=n119
XU357 OAI21X2TR $PINS A0=n922 A1=FE_OCPN143_n879 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n884
XU359 NAND2X1TR $PINS A=n1783 B=n2229 Y=n1057
XU360 NOR2X1TR $PINS A=n1783 B=n2229 Y=n1058
XU361 CLKXOR2X2TR $PINS A=n290 B=n1115 Y=PE_top0_adder0_out_int2<1>
XU362 AOI21X1TR $PINS A0=n1118 A1=n1119 B0=n289 Y=n1115
XU363 OAI2BB1X1TR $PINS A0N=n1763 A1N=n1736 B0=n124 Y=n576
XU364 XNOR2X1TR $PINS A=n514 B=n515 Y=n107
XU365 NOR2BX1TR $PINS AN=n507 B=FE_OFN114_reset Y=n515
XU366 INVX2TR $PINS A=n477 Y=n793
XU367 NOR2X2TR $PINS A=n476 B=n475 Y=n477
XU368 CMPR22X2TR $PINS A=n211 B=n210 S=n357 CO=n828
XU369 OAI22X2TR $PINS A0=n821 A1=n194 B0=n819 B1=n193 Y=n210
XU370 OAI22X2TR $PINS A0=n386 A1=n380 B0=n374 B1=n384 Y=n378
XU371 XNOR2X1TR $PINS A=n1384 B=n817 Y=n374
XU372 XNOR2X1TR $PINS A=n1359 B=n740 Y=n416
XU373 NOR2X1TR $PINS A=n657 B=n656 Y=PE_top0_buff_mult_arr0_mult_x_30_n26
XU374 ADDFHX2TR $PINS A=n652 B=n651 CI=n650 S=n657 CO=n649
XU378 NAND2X1TR $PINS A=n189 B=n188 Y=n795
XU379 XOR2X1TR $PINS A=n582 B=n62 Y=n61
XU380 ADDFHX2TR $PINS A=n278 B=n277 CI=n276 S=n650 CO=n582
XU381 OAI2BB1X2TR $PINS A0N=n1761 A1N=n1758 B0=n93 Y=n385
XU382 XNOR2X4TR $PINS A=n1384 B=n804 Y=n198
XU383 XNOR2X1TR $PINS A=n1382 B=n804 Y=n801
XU384 NOR2BX1TR $PINS AN=n513 B=FE_OFN114_reset Y=n514
XU385 NAND2X2TR $PINS A=n196 B=n195 Y=n197
XU386 NAND2X1TR $PINS A=n739 B=n738 Y=PE_top0_buff_mult_arr0_mult_x_30_n13
XU387 NOR2X1TR $PINS A=n794 B=PE_top0_buff_mult_arr0_mult_x_27_n29
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n24
XU388 OAI21X1TR $PINS A0=n794 A1=PE_top0_buff_mult_arr0_mult_x_27_n30 B0=n795
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n25
XU389 OAI21X1TR $PINS A0=n76 A1=n616 B0=n75 Y=n1727
XU390 NAND2X1TR $PINS A=pe_out_pk_data__7_ B=n1072 Y=n76
XU391 AOI21X2TR $PINS A0=n734 A1=n733 B0=n732 Y=n737
XU392 INVX2TR $PINS A=n146 Y=n141
XU393 XNOR2X1TR $PINS A=n1323 B=n307 Y=n146
XU395 XNOR2X1TR $PINS A=n1378 B=n123 Y=n815
XU396 XNOR2X1TR $PINS A=n1382 B=n385 Y=n381
XU398 XNOR2X1TR $PINS A=n1341 B=n576 Y=n722
XU399 XNOR2X1TR $PINS A=n385 B=n1378 Y=n207
XU400 ADDFHX2TR $PINS A=n161 B=n186 CI=n185 S=n780 CO=n188
XU401 NAND2BX1TR $PINS AN=n49 B=n1744 Y=n48
XU402 CLKINVX2TR $PINS A=n1762 Y=n49
XU403 AOI21X1TR $PINS A0=n5 A1=n643 B0=n431 Y=n332
XU404 OAI21X1TR $PINS A0=n437 A1=PE_top0_buff_mult_arr0_mult_x_33_n30 B0=n436
+ Y=n438
XU405 OR2X4TR $PINS A=n774 B=n773 Y=n776
XU406 XOR3X2TR $PINS A=n765 B=n764 C=n763 Y=n774
XU407 NAND2X1TR $PINS A=n461 B=n460 Y=n462
XU408 XOR2X4TR $PINS A=n95 B=n236 Y=n94
XU409 XOR2X4TR $PINS A=n237 B=n96 Y=n95
XU410 XNOR2X1TR $PINS A=n1363 B=n752 Y=n182
XU411 AO21X2TR $PINS A0=n453 A1=n454 B0=n417 Y=n772
XU412 XNOR2X1TR $PINS A=n1363 B=n749 Y=n417
XU413 NAND3X2TR $PINS A=n121 B=n120 C=n844 Y=n593
XU414 OAI22X1TR $PINS A0=n386 A1=n191 B0=n385 B1=n384 Y=n390
XU415 XNOR2X1TR $PINS A=n1384 B=n123 Y=n383
XU416 OAI2BB1X2TR $PINS A0N=n59 A1N=n581 B0=n58 Y=n706
XU417 ADDFHX2TR $PINS A=n357 B=n356 CI=n355 S=n367 CO=n839
XU418 OAI22X1TR $PINS A0=n712 A1=n267 B0=n710 B1=n575 Y=n571
XU419 XOR2X1TR $PINS A=n53 B=n822 Y=n52
XU420 XOR2X4TR $PINS A=n539 B=n103 Y=PE_top0_DP_OP_17J1_122_4844_n2
XU421 XOR2X4TR $PINS A=n104 B=n517 Y=n103
XU422 XNOR2X1TR $PINS A=n615 B=n614 Y=n77
XU423 OAI21X1TR $PINS A0=n876 A1=n873 B0=n874 Y=n615
XU425 NOR2X1TR $PINS A=n1785 B=n1806 Y=n870
XU426 OAI21X1TR $PINS A0=n14 A1=n302 B0=n301 Y=n1138
XU427 NOR2BX2TR $PINS AN=n501 B=FE_OFN0_FE_DBTN0_n2195 Y=n502
XU428 XNOR2X2TR $PINS A=n500 B=n1365 Y=n501
XU429 XNOR2X1TR $PINS A=n1325 B=n140 Y=n309
XU430 NOR2BX1TR $PINS AN=n486 B=FE_OFN114_reset Y=n106
XU432 XNOR2X1TR $PINS A=n1361 B=n752 Y=n751
XU433 AO22X2TR $PINS A0=n1762 A1=n1745 B0=n1868 B1=n1926 Y=n752
XU434 XNOR2X2TR $PINS A=n1361 B=n749 Y=n758
XU435 OAI2BB1X2TR $PINS A0N=n1868 A1N=n1886 B0=n48 Y=n749
XU436 AO22X2TR $PINS A0=n1761 A1=n1753 B0=n1867 B1=n1928 Y=n804
XU438 CLKXOR2X2TR $PINS A=n106 B=n516 Y=n105
XU439 NOR2BX2TR $PINS AN=n502 B=FE_OFN114_reset Y=n516
XU440 XOR2X4TR $PINS A=n107 B=n105 Y=n104
XU441 NAND2X1TR $PINS A=n2105 B=n1869 Y=n63
XU442 INVX1TR $PINS A=n1382 Y=n399
XU443 OAI22X2TR $PINS A0=n243 A1=n240 B0=n241 B1=n226 Y=n245
XU444 CLKINVX2TR $PINS A=n235 Y=n244
XU445 INVX2TR $PINS A=n74 Y=n73
XU446 INVX1TR $PINS A=n1337 Y=n269
XU447 NAND2BX1TR $PINS AN=n1366 B=n1367 Y=n100
XU448 AND2X1TR $PINS A=n497 B=n1352 Y=n88
XU449 OR2X2TR $PINS A=FE_OFN114_reset B=FE_OFN0_FE_DBTN0_n2195 Y=n87
XU450 NOR2X2TR $PINS A=n758 B=n169 Y=n46
XU451 INVX1TR $PINS A=n1321 Y=n150
XU452 CLKINVX2TR $PINS A=n699 Y=n85
XU453 NAND2BX1TR $PINS AN=n116 B=n772 Y=n113
XU454 NAND2BX1TR $PINS AN=n772 B=n116 Y=n114
XU455 AO21X1TR $PINS A0=n386 A1=n384 B0=n209 Y=n829
XU456 OAI22X1TR $PINS A0=n264 A1=n262 B0=n676 B1=n677 Y=n684
XU457 CLKINVX2TR $PINS A=n257 Y=n674
XU458 OAI22X2TR $PINS A0=n806 A1=n813 B0=n812 B1=n811 Y=n827
XU459 OAI22X2TR $PINS A0=n821 A1=n815 B0=n819 B1=n820 Y=n826
XU460 OR2X1TR $PINS A=n630 B=n629 Y=n625
XU462 INVX2TR $PINS A=n401 Y=n70
XU463 OR2X1TR $PINS A=n1788 B=n2232 Y=n613
XU464 NAND3BX1TR $PINS AN=n1822 B=n1072 C=FE_OFN29_FE_DBTN1_reset Y=n878
XU465 NAND2X1TR $PINS A=n1113 B=n1112 Y=PE_top0_DP_OP_17J1_122_4844_n35
XU466 AND2X1TR $PINS A=n856 B=n867 Y=n857
XU467 OR2X1TR $PINS A=n1781 B=n1804 Y=n856
XU469 OR2X1TR $PINS A=n1353 B=n1346 Y=n509
XU470 INVX1TR $PINS A=n1347 Y=n90
XU471 OAI21X1TR $PINS A0=n1351 A1=n1348 B0=n1349 Y=n494
XU472 NOR2X1TR $PINS A=n1348 B=n1350 Y=n495
XU473 XNOR2X1TR $PINS A=n1323 B=n228 Y=n238
XU474 INVX1TR $PINS A=n1319 Y=n136
XU475 INVX1TR $PINS A=n137 Y=n142
XU476 NAND2BX1TR $PINS AN=n132 B=n1321 Y=n149
XU477 XNOR2X2TR $PINS A=n716 B=n1343 Y=n274
XU478 NAND2X1TR $PINS A=n168 B=FE_OCPN141_n162 Y=n163
XU479 XNOR2X1TR $PINS A=n1378 B=n191 Y=n192
XU480 NAND2BX1TR $PINS AN=n191 B=n1378 Y=n193
XU481 NAND2X1TR $PINS A=n1757 B=n1761 Y=n71
XU482 NOR3XLTR $PINS A=FE_OFN71_pe_in_pk_rdb_addr__0
+ B=FE_OFN89_pe_in_pk_rdb_addr__2 C=n1077 Y=n1096
XU483 XNOR2X1TR $PINS A=n1341 B=n266 Y=n675
XU484 XNOR2X1TR $PINS A=n545 B=n1368 Y=n546
XU485 OR2X1TR $PINS A=n1372 B=n1366 Y=n499
XU486 OA21XLTR $PINS A0=n1366 A1=n1373 B0=n1367 Y=n498
XU487 XNOR2X1TR $PINS A=n1380 B=n802 Y=n811
XU488 XNOR2X1TR $PINS A=n1323 B=n227 Y=n232
XU489 XNOR2X1TR $PINS A=n1321 B=n307 Y=n247
XU490 XNOR2X1TR $PINS A=n310 B=n1321 Y=n50
XU491 AO21X1TR $PINS A0=n259 A1=n257 B0=n722 Y=n725
XU492 XNOR2X1TR $PINS A=n1337 B=n266 Y=n268
XU493 OR2X2TR $PINS A=n270 B=n710 Y=n271
XU494 XNOR2X1TR $PINS A=n1361 B=n414 Y=n184
XU495 OAI22X1TR $PINS A0=n748 A1=n178 B0=n746 B1=n177 Y=n418
XU496 INVX1TR $PINS A=n1357 Y=n178
XU497 OAI22X2TR $PINS A0=n821 A1=n192 B0=n819 B1=n207 Y=n211
XU498 INVX1TR $PINS A=n1378 Y=n194
XU499 XNOR2X1TR $PINS A=n1382 B=n814 Y=n370
XU500 NOR2X1TR $PINS A=n57 B=n56 Y=n55
XU501 NOR2X1TR $PINS A=n821 B=n207 Y=n56
XU502 NOR3X1TR $PINS A=pe_in_pk_rdb_addr__1_ B=n1078 C=n1079 Y=n1076
XU503 NOR3BX1TR $PINS AN=n1079 B=FE_OFN89_pe_in_pk_rdb_addr__2
+ C=pe_in_pk_rdb_addr__1_ Y=n1080
XU504 NOR3X1TR $PINS A=n1079 B=n1078 C=n1077 Y=n1101
XU505 AND3X4TR $PINS A=n1079 B=n1077 C=FE_OFN89_pe_in_pk_rdb_addr__2 Y=n1099
XU506 AND2X1TR $PINS A=FE_OFN71_pe_in_pk_rdb_addr__0 B=pe_in_pk_rdb_addr__1_
+ Y=n1074
XU507 NAND2BX1TR $PINS AN=n191 B=n1384 Y=n388
XU508 INVX1TR $PINS A=n1361 Y=n469
XU509 OAI22X1TR $PINS A0=n453 A1=FE_OCPN141_n162 B0=n159 B1=n454 Y=n459
XU510 NAND2BX1TR $PINS AN=FE_OCPN141_n162 B=n1363 Y=n457
XU511 NOR2BX1TR $PINS AN=n132 B=n137 Y=n299
XU512 NAND2BX1TR $PINS AN=n132 B=n1325 Y=n296
XU513 OAI22X1TR $PINS A0=n139 A1=n293 B0=n137 B1=n292 Y=n303
XU514 INVX1TR $PINS A=n1323 Y=n293
XU515 NAND2BX1TR $PINS AN=n132 B=n1323 Y=n292
XU516 NOR2X1TR $PINS A=n1784 B=n2230 Y=n1060
XU517 ADDHX1TR $PINS A=n466 B=n465 S=n471 CO=n473
XU518 XNOR2X1TR $PINS A=n1361 B=FE_OCPN141_n162 Y=n451
XU519 NAND2X1TR $PINS A=n1122 B=n1123 Y=n67
XU520 NOR2BX1TR $PINS AN=n506 B=n1865 Y=n507
XU521 OAI22X2TR $PINS A0=n320 A1=n319 B0=n318 B1=n317 Y=n426
XU522 CMPR32X2TR $PINS A=n655 B=n654 C=n653 S=n659 CO=n656
XU523 CLKINVX1TR $PINS A=n661 Y=n607
XU524 OR2X1TR $PINS A=n572 B=n571 Y=n731
XU525 NAND2BX1TR $PINS AN=n60 B=n582 Y=n58
XU526 NAND2BX1TR $PINS AN=n582 B=n60 Y=n59
XU527 XNOR2X1TR $PINS A=n273 B=n74 Y=n652
XU529 NAND2X1TR $PINS A=n366 B=n367 Y=n591
XU530 NAND3X1TR $PINS A=n845 B=n843 C=n841 Y=n121
XU531 NAND2X2TR $PINS A=n845 B=n481 Y=n120
XU532 CLKINVX2TR $PINS A=n840 Y=n481
XU533 NAND3X1TR $PINS A=pe_in_pk_rdb_addr__3_ B=FE_OFN12_n1080 C=FE_DBTN1_reset
+ Y=n1305
XU541 XOR2X1TR $PINS A=n1386 B=n334 Y=n335
XU542 NOR2BX1TR $PINS AN=n1777 B=FE_OFN113_reset Y=n285
XU543 OAI21X1TR $PINS A0=n464 A1=n463 B0=n462 Y=n1128
XU544 NAND2X1TR $PINS A=n459 B=n458 Y=n463
XU545 INVX1TR $PINS A=n684 Y=n687
XU546 OR2X2TR $PINS A=n304 B=n303 Y=n1137
XU547 INVX1TR $PINS A=n1766 Y=n851
XU548 INVX1TR $PINS A=n1060 Y=n1062
XU549 INVX1TR $PINS A=n871 Y=n66
XU550 INVX1TR $PINS A=n870 Y=n872
XU551 CLKINVX1TR $PINS A=n874 Y=n82
XU565 INVX4TR $PINS A=n910 Y=n988
XU568 OAI21X1TR $PINS A0=n946 A1=n945 B0=FE_OFN32_FE_DBTN1_reset Y=n947
XU569 INVX2TR $PINS A=n889 Y=n1037
XU570 AO22X1TR $PINS A0=n923 A1=FE_OFN42_n963 B0=FE_OFN56_n923 B1=n2059 Y=n1569
XU571 AO22X1TR $PINS A0=n910 A1=FE_OFN43_n967 B0=n988 B1=n2091 Y=n1597
XU572 AO22X1TR $PINS A0=n923 A1=n967 B0=FE_OFN56_n923 B1=n2099 Y=n1605
XU573 AO22X1TR $PINS A0=n910 A1=FE_OFN46_n971 B0=n988 B1=n2131 Y=n1633
XU574 AO22X1TR $PINS A0=n923 A1=FE_OFN46_n971 B0=FE_OFN56_n923 B1=n2139 Y=n1641
XU575 AO22X1TR $PINS A0=n910 A1=FE_OFN83_n975 B0=n988 B1=n2171 Y=n1669
XU576 AO22X1TR $PINS A0=n923 A1=FE_OFN48_n975 B0=FE_OFN56_n923 B1=n2179 Y=n1677
XU577 AO22X1TR $PINS A0=n910 A1=FE_OFN118_n B0=n988 B1=n2198 Y=n1693
XU578 AO22X1TR $PINS A0=n923 A1=FE_OFN116_n B0=FE_OFN56_n923 B1=n2207 Y=n1702
XU579 XNOR2X1TR $PINS A=n19 B=n18 Y=PE_top0_buff_mult_arr0_mult_x_24_n2
XU580 NAND2X1TR $PINS A=n428 B=n427 Y=PE_top0_buff_mult_arr0_mult_x_33_n30
XU581 NOR2X1TR $PINS A=n707 B=n706 Y=PE_top0_buff_mult_arr0_mult_x_30_n19
XU582 NAND2X1TR $PINS A=n791 B=n790 Y=PE_top0_buff_mult_arr0_mult_x_27_n23
XU583 NAND2X1TR $PINS A=n793 B=n792 Y=PE_top0_buff_mult_arr0_mult_x_27_n7
XU584 NOR2X1TR $PINS A=n847 B=n846 Y=PE_top0_buff_mult_arr0_mult_x_24_n19
XU585 NOR2X2TR $PINS A=n838 B=n839 Y=PE_top0_buff_mult_arr0_mult_x_24_n22
XU586 NOR2X1TR $PINS A=n590 B=n589 Y=PE_top0_buff_mult_arr0_mult_x_24_n29
XU587 NAND2X1TR $PINS A=n847 B=n846 Y=PE_top0_buff_mult_arr0_mult_x_24_n20
XU588 AND2X1TR $PINS A=n1815 B=FE_OFN29_FE_DBTN1_reset Y=PE_top0_ST_ADD<1>
XU589 AND2X1TR $PINS A=n1814 B=FE_OFN29_FE_DBTN1_reset Y=PE_top0_ST_ADD<2>
XU590 NAND2X1TR $PINS A=n865 B=n864 Y=PE_top0_DP_OP_17J1_122_4844_n18
XU591 AND2X1TR $PINS A=FE_OFN32_FE_DBTN1_reset B=n1125
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out1_0_
XU592 AND2X2TR $PINS A=n1775 B=FE_OFN29_FE_DBTN1_reset Y=PE_top0_OUT_ADD<1>
XU593 INVX1TR $PINS A=n1773 Y=n1141
XU594 AND2X2TR $PINS A=n1054 B=FE_OFN29_FE_DBTN1_reset Y=pe_out_pk_data__2_
XU595 INVX1TR $PINS A=n1058 Y=n1052
XU596 AND2X2TR $PINS A=n1071 B=FE_OFN118_n Y=pe_out_pk_data__5_
XU597 AND2X2TR $PINS A=n77 B=FE_OFN118_n Y=pe_out_pk_data__7_
XU598 AND2X1TR $PINS A=pe_out_pk_data__0_ B=n1072 Y=n866
XU599 AND2X1TR $PINS A=pe_out_pk_data__1_ B=n1072 Y=n869
XU600 AND2X1TR $PINS A=pe_out_pk_data__4_ B=n1072 Y=n41
XU601 AND2X2TR $PINS A=pe_out_pk_data__6_ B=n1072 Y=n877
XU602 AND2X1TR $PINS A=n1822 B=FE_OFN118_n Y=pe_out_pk_PE_state__0_
XU603 AND2X1TR $PINS A=n1816 B=FE_OFN29_FE_DBTN1_reset Y=PE_top0_ST_ADD<0>
XU605 NAND2X1TR $PINS A=n616 B=n2232 Y=n75
XU608 ADDFX2TR $PINS A=n379 B=n378 CI=n377 S=n403 CO=n376
XU609 OAI2BB1X1TR $PINS A0N=n778 A1N=n44 B0=n42 Y=n773
XU610 OAI21X1TR $PINS A0=n778 A1=n44 B0=n777 Y=n42
XU611 XOR2X1TR $PINS A=n43 B=n777 Y=n798
XU612 XOR2X1TR $PINS A=n778 B=n44 Y=n43
XU613 OR2X2TR $PINS A=n767 B=n766 Y=n44
XU614 XNOR2X2TR $PINS A=n45 B=n761 Y=n763
XU615 XOR2X2TR $PINS A=n762 B=n768 Y=n45
XU616 NOR2X4TR $PINS A=n47 B=n46 Y=n768
XU617 OAI22X4TR $PINS A0=n248 A1=n144 B0=n249 B1=n50 Y=n627
XU618 XOR2X1TR $PINS A=n809 B=n816 Y=n54
XU619 XOR2X1TR $PINS A=n824 B=n55 Y=n836
XU621 XOR2X1TR $PINS A=n581 B=n61 Y=n648
XU622 XNOR2X1TR $PINS A=n571 B=n572 Y=n62
XU623 OAI2BB1X2TR $PINS A0N=n1763 A1N=n1741 B0=n63 Y=n669
XU624 NAND2BX1TR $PINS AN=n66 B=n872 Y=n65
XU625 NAND2BX1TR $PINS AN=n394 B=n392 Y=n68
XU626 NAND2X1TR $PINS A=n70 B=n69 Y=n1122
XU627 OAI2BB1X2TR $PINS A0N=n1867 A1N=n2088 B0=n71 Y=n123
XU629 OAI21X1TR $PINS A0=n72 A1=n870 B0=n871 Y=n1070
XU630 AOI21X1TR $PINS A0=n1056 A1=n79 B0=n78 Y=n72
XU631 OA22X2TR $PINS A0=n268 A1=n712 B0=n267 B1=n710 Y=n74
XU632 OAI21X1TR $PINS A0=n1060 A1=n1057 B0=n1061 Y=n78
XU633 XNOR2X1TR $PINS A=n876 B=n81 Y=n80
XU634 NAND2BX1TR $PINS AN=n82 B=n875 Y=n81
XU635 AOI21X1TR $PINS A0=n1070 A1=n1068 B0=n611 Y=n876
XU636 NAND2X1TR $PINS A=n1738 B=n1763 Y=n83
XU637 OAI2BB1X2TR $PINS A0N=n1869 A1N=n1985 B0=n83 Y=n573
XU638 NAND2X1TR $PINS A=n86 B=n85 Y=n736
XU639 XNOR2X2TR $PINS A=n99 B=n662 Y=n86
XU640 OR2X4TR $PINS A=n865 B=n864 Y=n1395
XU641 AOI2BB1X1TR $PINS A0N=n1353 A1N=n534 B0=n90 Y=n89
XU642 CLKINVX2TR $PINS A=n1387 Y=n518
XU643 AO22X4TR $PINS A0=n2048 A1=n1867 B0=n1756 B1=n1761 Y=n814
XU644 NAND2X1TR $PINS A=n2128 B=n1867 Y=n93
XU645 XNOR2X4TR $PINS A=n97 B=n233 Y=n96
XU646 XOR2X1TR $PINS A=n234 B=n235 Y=n97
XU647 OAI2BB1X2TR $PINS A0N=n1870 A1N=n2030 B0=n98 Y=n307
XU648 NAND2X1TR $PINS A=n1764 B=n1731 Y=n98
XU649 XOR2X1TR $PINS A=n661 B=n660 Y=n99
XU650 CLKINVX2TR $PINS A=n1372 Y=n523
XU651 XNOR2X1TR $PINS A=n101 B=n100 Y=n487
XU652 OAI21X1TR $PINS A0=n525 A1=n1372 B0=n1373 Y=n101
XU653 NOR2X4TR $PINS A=n1375 B=n102 Y=n525
XU654 AND2X2TR $PINS A=n1371 B=n1376 Y=n102
XU655 NAND2BX1TR $PINS AN=n738 B=n108 Y=n1356
XU656 XOR2X4TR $PINS A=n110 B=n725 Y=n109
XU657 XOR2X2TR $PINS A=n111 B=n726 Y=n110
XU658 OAI22X4TR $PINS A0=n259 A1=n577 B0=n722 B1=n257 Y=n726
XU659 OAI22X1TR $PINS A0=n718 A1=n719 B0=n721 B1=n720 Y=n111
XU660 NAND2X1TR $PINS A=n1739 B=n1763 Y=n112
XU661 OAI2BB1X2TR $PINS A0N=n1869 A1N=n2025 B0=n112 Y=n708
XU662 OAI2BB1X1TR $PINS A0N=n114 A1N=n771 B0=n113 Y=n777
XU663 XNOR2X4TR $PINS A=n771 B=n115 Y=n787
XU664 XOR2X2TR $PINS A=n772 B=n116 Y=n115
XU665 AOI21X1TR $PINS A0=n24 A1=n23 B0=n22
+ Y=PE_top0_buff_mult_arr0_mult_x_24_n1
XU667 OAI22X1TR $PINS A0=n264 A1=n274 B0=n677 B1=n265 Y=n278
XU668 NAND2BX1TR $PINS AN=n126 B=n1737 Y=n125
XU669 NAND2BX1TR $PINS AN=n128 B=n1945 Y=n127
XU671 NAND2X1TR $PINS A=n2008 B=n1867 Y=n129
XU672 OAI2BB1X2TR $PINS A0N=n1761 A1N=n1755 B0=n129 Y=n817
XU673 NOR2BX1TR $PINS AN=n485 B=FE_DBTN0_n2195 Y=n486
XU674 NOR2BX1TR $PINS AN=n342 B=FE_OFN0_FE_DBTN0_n2195 Y=n343
XU675 NOR2BX1TR $PINS AN=n335 B=FE_DBTN0_n2195 Y=n336
XU676 NOR2BX1TR $PINS AN=n1864 B=FE_DBTN0_n2195 Y=n220
XU677 NOR2BX1TR $PINS AN=n216 B=FE_OFN0_FE_DBTN0_n2195 Y=n217
XU678 XOR2X2TR $PINS A=n525 B=n524 Y=n526
XU679 XOR2X1TR $PINS A=n1336 B=n529 Y=n530
XU680 OAI22X1TR $PINS A0=n806 A1=n359 B0=n812 B1=n358 Y=n585
XU681 OAI22X1TR $PINS A0=n757 A1=n166 B0=FE_OCPN142_n157 B1=n183 Y=n161
XU682 XNOR2X1TR $PINS A=n1361 B=n160 Y=n444
XU683 XNOR2X1TR $PINS A=n1339 B=n663 Y=n263
XU684 OAI22X2TR $PINS A0=n264 A1=n602 B0=n274 B1=n677 Y=n600
XU685 OAI22X1TR $PINS A0=n259 A1=n603 B0=n257 B1=n275 Y=n599
XU686 AOI21X2TR $PINS A0=n432 A1=n431 B0=n430 Y=n433
XU687 NAND2X4TR $PINS A=n201 B=n812 Y=n806
XU688 OA21XLTR $PINS A0=n1346 A1=n1347 B0=n1352 Y=n508
XU689 OR2X2TR $PINS A=n1388 B=n1387 Y=n483
XU690 XNOR2X1TR $PINS A=n511 B=n510 Y=n512
XU691 NOR2BX1TR $PINS AN=n512 B=FE_OFN0_FE_DBTN0_n2195 Y=n513
XU692 OAI21X1TR $PINS A0=n1386 A1=n1390 B0=n1391 Y=n561
XU693 XNOR2X1TR $PINS A=n1319 B=n310 Y=n240
XU694 NAND2X2TR $PINS A=n1363 B=n454 Y=n453
XU695 OAI22X1TR $PINS A0=n320 A1=n132 B0=n133 B1=n317 Y=n298
XU696 OAI22X1TR $PINS A0=n243 A1=n136 B0=n241 B1=n135 Y=n251
XU697 OAI21X2TR $PINS A0=n924 A1=FE_OCPN143_n879 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n883
XU698 CMPR22X2TR $PINS A=n174 B=n173 S=n440 CO=n186
XU699 OAI21X2TR $PINS A0=n920 A1=FE_OCPN143_n879 B0=FE_OFN115_n Y=n882
XU700 OAI21X4TR $PINS A0=n932 A1=FE_OCPN143_n879 B0=FE_OFN115_n Y=n933
XU701 NAND2X1TR $PINS A=n647 B=n646 Y=PE_top0_buff_mult_arr0_mult_x_33_n20
XU702 NAND2X1TR $PINS A=n798 B=n797 Y=PE_top0_buff_mult_arr0_mult_x_27_n20
XU703 AOI21X1TR $PINS A0=n843 A1=n841 B0=n481
+ Y=PE_top0_buff_mult_arr0_mult_x_24_n39
XU704 XNOR2X4TR $PINS A=n1320 B=n1321 Y=n241
XU705 AND2X2TR $PINS A=n130 B=n241 Y=n131
XU706 INVX2TR $PINS A=n131 Y=n243
XU707 AO22X4TR $PINS A0=n1764 A1=n1735 B0=n1870 B1=n2190 Y=n132
XU708 XNOR2X1TR $PINS A=n1319 B=n132 Y=n134
XU709 AO22X4TR $PINS A0=n1764 A1=n1734 B0=n1870 B1=n2150 Y=n133
XU710 XNOR2X1TR $PINS A=n1319 B=n133 Y=n242
XU711 OAI22X2TR $PINS A0=n243 A1=n134 B0=n241 B1=n242 Y=n252
XU712 NAND2BX1TR $PINS AN=n132 B=n1319 Y=n135
XU713 NOR2BX1TR $PINS AN=n132 B=n241 Y=n153
XU714 NAND2X2TR $PINS A=n1325 B=n317 Y=n320
XU715 AO22X4TR $PINS A0=n1764 A1=n1730 B0=n1870 B1=n1990 Y=n225
XU716 AO22X4TR $PINS A0=n1764 A1=n1729 B0=n1870 B1=n1950 Y=n228
XU717 XNOR2X2TR $PINS A=n1325 B=n228 Y=n143
XU718 OAI22X4TR $PINS A0=n320 A1=n318 B0=n143 B1=n317 Y=n152
XU719 XOR2X1TR $PINS A=n1324 B=n1323 Y=n138
XU720 XNOR2X4TR $PINS A=n1324 B=n1325 Y=n137
XU722 NAND2X4TR $PINS A=n138 B=n137 Y=n139
XU724 AO22X4TR $PINS A0=n1764 A1=n1732 B0=n1870 B1=n2070 Y=n140
XU725 OAI2BB2X1TR $PINS A0N=n142 A1N=n141 B0=n139 B1=n321 Y=n151
XU726 AO22X2TR $PINS A0=n1764 A1=n1728 B0=n1870 B1=n1910 Y=n227
XU727 XNOR2X2TR $PINS A=n1325 B=n227 Y=n250
XU728 OAI22X4TR $PINS A0=n320 A1=n143 B0=n250 B1=n317 Y=n628
XU729 XOR2X1TR $PINS A=n1322 B=n1321 Y=n145
XU730 XNOR2X4TR $PINS A=n1322 B=n1323 Y=n144
XU731 NAND2X4TR $PINS A=n145 B=n144 Y=n249
XU732 AO22X4TR $PINS A0=n1764 A1=n1733 B0=n1870 B1=n2110 Y=n310
XU733 XNOR2X1TR $PINS A=n1321 B=n140 Y=n248
XU734 XNOR2X1TR $PINS A=n1323 B=n225 Y=n239
XU735 OAI22X1TR $PINS A0=n139 A1=n146 B0=n137 B1=n239 Y=n626
XU736 XNOR2X1TR $PINS A=n1321 B=n133 Y=n147
XU737 OAI22X4TR $PINS A0=n249 A1=n148 B0=n144 B1=n147 Y=n325
XU738 OAI22X4TR $PINS A0=n249 A1=n150 B0=n144 B1=n149 Y=n324
XU739 ADDFHX2TR $PINS A=n153 B=n152 CI=n151 S=n421 CO=n638
XU740 NOR2X4TR $PINS A=n155 B=n154 Y=n437
XU741 INVX2TR $PINS A=n437 Y=n156
XU742 NAND2X1TR $PINS A=n155 B=n154 Y=n436
XU743 NAND2X1TR $PINS A=n156 B=n436 Y=PE_top0_buff_mult_arr0_mult_x_33_n5
XU744 XOR2X1TR $PINS A=n1360 B=n1359 Y=n158
XU745 XNOR2X2TR $PINS A=n1360 B=n1361 Y=n157
XU747 NAND2X2TR $PINS A=n158 B=n157 Y=n757
XU748 XNOR2X1TR $PINS A=n1359 B=n159 Y=n166
XU749 INVX2TR $PINS A=n757 Y=n165
XU750 AO22X2TR $PINS A0=n1762 A1=n1751 B0=n1868 B1=n2166 Y=n162
XU752 NAND2BX2TR $PINS AN=FE_OCPN141_n162 B=n1359 Y=n167
XU753 CLKINVX2TR $PINS A=n1359 Y=n168
XU754 NAND2X1TR $PINS A=n167 B=n163 Y=n164
XU755 OAI2BB2X4TR $PINS A0N=n165 A1N=n164 B0=FE_OCPN142_n157 B1=n166 Y=n174
XU756 XNOR2X2TR $PINS A=n1358 B=n1359 Y=n746
XU758 AO22X4TR $PINS A0=n1762 A1=n1746 B0=n1868 B1=n1966 Y=n743
XU760 XNOR2X4TR $PINS A=n1362 B=n1363 Y=n169
XU761 NAND2X4TR $PINS A=n169 B=n170 Y=n760
XU762 AO22X4TR $PINS A0=n1762 A1=n1748 B0=n1868 B1=n2046 Y=n740
XU763 XNOR2X1TR $PINS A=n1361 B=n740 Y=n172
XU764 AO22X4TR $PINS A0=n1762 A1=n1747 B0=n1868 B1=n2006 Y=n414
XU765 XNOR2X1TR $PINS A=n1363 B=n414 Y=n443
XU766 OAI22X1TR $PINS A0=n453 A1=n443 B0=n171 B1=n454 Y=n442
XU767 OAI22X2TR $PINS A0=n760 A1=n444 B0=n169 B1=n172 Y=n441
XU768 XOR2X1TR $PINS A=n1358 B=n1357 Y=n175
XU770 XNOR2X1TR $PINS A=n1357 B=n159 Y=n413
XU771 OAI22X2TR $PINS A0=n748 A1=n176 B0=n746 B1=n413 Y=n419
XU772 NAND2BX1TR $PINS AN=FE_OCPN141_n162 B=n1357 Y=n177
XU773 ADDFHX4TR $PINS A=n181 B=n180 CI=n179 S=n185 CO=n407
XU774 OAI22X2TR $PINS A0=n182 A1=n453 B0=n417 B1=n454 Y=n411
XU775 OAI22X2TR $PINS A0=n757 A1=n183 B0=FE_OCPN142_n157 B1=n416 Y=n410
XU777 XNOR2X2TR $PINS A=n1379 B=n1380 Y=n819
XU779 AO22X2TR $PINS A0=n1761 A1=n1759 B0=n1867 B1=n2168 Y=n191
XU780 AO22X2TR $PINS A0=n1761 A1=n1754 B0=n1867 B1=n1968 Y=n802
XU781 XNOR2X2TR $PINS A=n1384 B=n802 Y=n369
XU782 OAI22X4TR $PINS A0=n386 A1=n369 B0=n198 B1=n384 Y=n364
XU783 XOR2X1TR $PINS A=n1383 B=n1382 Y=n196
XU784 XNOR2X4TR $PINS A=n1383 B=n1384 Y=n195
XU785 XNOR2X1TR $PINS A=n1382 B=n817 Y=n202
XU786 OAI22X1TR $PINS A0=n197 A1=n370 B0=n195 B1=n202 Y=n363
XU787 AO22X2TR $PINS A0=n1761 A1=n1752 B0=n1867 B1=n1888 Y=n799
XU789 OAI22X2TR $PINS A0=n386 A1=n198 B0=n209 B1=n384 Y=n205
XU790 CLKINVX2TR $PINS A=n1381 Y=n199
XU791 XNOR2X2TR $PINS A=n199 B=n1382 Y=n200
XU793 XNOR2X1TR $PINS A=n1380 B=n123 Y=n358
XU794 OAI22X4TR $PINS A0=n806 A1=n358 B0=n812 B1=n208 Y=n204
XU795 XNOR2X1TR $PINS A=n1380 B=n817 Y=n813
XU797 NOR2BX1TR $PINS AN=n212 B=FE_DBTN0_n2195 Y=n213
XU799 NOR2BX1TR $PINS AN=n213 B=FE_OFN113_reset Y=n354
XU800 NOR2BX1TR $PINS AN=n1863 B=FE_OFN0_FE_DBTN0_n2195 Y=n214
XU801 NOR2BX1TR $PINS AN=n214 B=FE_OFN112_reset Y=n223
XU802 NOR2BX1TR $PINS AN=n1859 B=FE_DBTN0_n2195 Y=n215
XU804 NOR2BX1TR $PINS AN=n215 B=FE_OFN9_reset Y=n222
XU805 XOR2X1TR $PINS A=n1377 B=n1374 Y=n216
XU806 NOR2BX1TR $PINS AN=n217 B=FE_OFN113_reset Y=n339
XU807 NOR2BX1TR $PINS AN=n1860 B=FE_DBTN0_n2195 Y=n218
XU808 NOR2BX1TR $PINS AN=n218 B=FE_OFN9_reset Y=n338
XU809 NOR2BX1TR $PINS AN=n1862 B=FE_OFN0_FE_DBTN0_n2195 Y=n219
XU810 NOR2BX1TR $PINS AN=n219 B=FE_OFN113_reset Y=n337
XU811 NOR2BX1TR $PINS AN=n220 B=FE_OFN113_reset Y=n281
XU812 NOR2BX1TR $PINS AN=n1861 B=FE_OFN0_FE_DBTN0_n2195 Y=n221
XU813 NOR2BX1TR $PINS AN=n221 B=FE_OFN113_reset Y=n280
XU814 XNOR2X1TR $PINS A=n1319 B=n140 Y=n226
XU815 XNOR2X1TR $PINS A=n1319 B=n307 Y=n224
XU816 OAI22X1TR $PINS A0=n243 A1=n226 B0=n241 B1=n224 Y=n237
XU817 XNOR2X1TR $PINS A=n1321 B=n225 Y=n231
XU818 OAI22X2TR $PINS A0=n247 A1=n249 B0=n144 B1=n231 Y=n246
XU819 OAI22X4TR $PINS A0=n139 A1=n238 B0=n137 B1=n232 Y=n235
XU820 XNOR2X1TR $PINS A=n1321 B=n228 Y=n230
XU821 OAI22X1TR $PINS A0=n249 A1=n231 B0=n144 B1=n230 Y=n234
XU822 OAI22X1TR $PINS A0=n139 A1=n239 B0=n137 B1=n238 Y=n630
XU823 OAI22X1TR $PINS A0=n243 A1=n242 B0=n241 B1=n240 Y=n629
XU824 ADDFHX2TR $PINS A=n246 B=n245 CI=n244 S=n624 CO=n236
XU825 OAI22X1TR $PINS A0=n249 A1=n248 B0=n144 B1=n247 Y=n633
XU826 AO21X1TR $PINS A0=n320 A1=n317 B0=n250 Y=n632
XU827 CMPR22X2TR $PINS A=n252 B=n251 S=n639 CO=n631
XU828 INVX2TR $PINS A=n1344 Y=n677
XU830 XOR2X1TR $PINS A=n1340 B=n1339 Y=n256
XU831 CLKINVX2TR $PINS A=n1340 Y=n254
XU833 XNOR2X2TR $PINS A=n254 B=n1341 Y=n255
XU835 XNOR2X1TR $PINS A=n1339 B=n669 Y=n594
XU836 AO22X2TR $PINS A0=n1763 A1=n1740 B0=n1869 B1=n2065 Y=n663
XU837 OAI22X2TR $PINS A0=n721 A1=n594 B0=n719 B1=n263 Y=n277
XU838 XOR2X1TR $PINS A=n1342 B=n1341 Y=n258
XU839 XNOR2X4TR $PINS A=n1342 B=n1343 Y=n257
XU840 XNOR2X1TR $PINS A=n1341 B=n708 Y=n275
XU841 XNOR2X1TR $PINS A=n1341 B=n573 Y=n260
XU842 OAI22X1TR $PINS A0=n259 A1=n275 B0=n257 B1=n260 Y=n276
XU843 XNOR2X2TR $PINS A=n1341 B=n716 Y=n577
XU844 XOR2X1TR $PINS A=n1338 B=n1337 Y=n261
XU845 XNOR2X2TR $PINS A=n1338 B=n1339 Y=n710
XU846 NAND2X2TR $PINS A=n261 B=n710 Y=n712
XU847 AO22X2TR $PINS A0=n1763 A1=n1742 B0=n1869 B1=n2145 Y=n262
XU849 XNOR2X1TR $PINS A=n1337 B=n262 Y=n267
XU850 XNOR2X1TR $PINS A=n1337 B=n669 Y=n575
XU851 XNOR2X1TR $PINS A=n1339 B=n708 Y=n574
XU852 AO22X2TR $PINS A0=n1763 A1=n1743 B0=n1869 B1=n2185 Y=n266
XU854 OR2X2TR $PINS A=n712 B=n269 Y=n272
XU855 NAND2BX1TR $PINS AN=n266 B=n1337 Y=n270
XU856 NOR2BX1TR $PINS AN=n266 B=n710 Y=n601
XU857 XNOR2X1TR $PINS A=n1343 B=n573 Y=n602
XU858 NOR2X1TR $PINS A=n648 B=n649 Y=PE_top0_buff_mult_arr0_mult_x_30_n22
XU859 ADDFX2TR $PINS A=n281 B=n280 CI=n279 S=n283 CO=n1112
XU860 NOR2X1TR $PINS A=n283 B=n282 Y=n1116
XU861 NAND2X1TR $PINS A=n283 B=n282 Y=n1114
XU862 NAND2X2TR $PINS A=n284 B=n1114 Y=n290
XU863 NOR2BX1TR $PINS AN=n1780 B=FE_OFN113_reset Y=n288
XU864 OR2X2TR $PINS A=n288 B=n287 Y=n1118
XU865 ADDHXLTR $PINS A=n286 B=n285 S=n1119 CO=n282
XU866 NAND2X1TR $PINS A=n288 B=n287 Y=n1117
XU867 OAI22X2TR $PINS A0=n320 A1=n294 B0=n309 B1=n317 Y=n314
XU868 OAI22X1TR $PINS A0=n139 A1=n291 B0=n137 B1=n312 Y=n313
XU869 INVX1TR $PINS A=n296 Y=n297
XU870 NOR2BX1TR $PINS AN=n132 B=n144 Y=n328
XU871 OAI22X2TR $PINS A0=n320 A1=n309 B0=n319 B1=n317 Y=n327
XU872 OAI22X1TR $PINS A0=n139 A1=n312 B0=n137 B1=n323 Y=n326
XU873 NAND2X1TR $PINS A=n316 B=n315 Y=n642
XU874 OAI22X2TR $PINS A0=n139 A1=n323 B0=n137 B1=n321 Y=n425
XU875 CMPR22X2TR $PINS A=n325 B=n324 S=n424 CO=n422
XU876 ADDFHX1TR $PINS A=n328 B=n327 CI=n326 S=n316 CO=n330
XU877 NAND2X1TR $PINS A=n330 B=n329 Y=n429
XU878 INVX1TR $PINS A=n1390 Y=n333
XU879 NAND2X1TR $PINS A=n333 B=n1391 Y=n334
XU880 NOR2BX1TR $PINS AN=n336 B=FE_OFN9_reset Y=n622
XU881 CMPR32X2TR $PINS A=n339 B=n338 C=n337 S=n352 CO=n621
XU882 INVX2TR $PINS A=n1376 Y=n544
XU883 INVX2TR $PINS A=n1369 Y=n340
XU884 NAND2X1TR $PINS A=n340 B=n1370 Y=n341
XU885 XOR2X1TR $PINS A=n544 B=n341 Y=n342
XU886 NOR2BX1TR $PINS AN=n343 B=FE_OFN113_reset Y=n570
XU887 CLKINVX2TR $PINS A=n1335 Y=n344
XU888 NAND2X1TR $PINS A=n344 B=n1334 Y=n345
XU890 NOR2BX1TR $PINS AN=n346 B=FE_DBTN0_n2195 Y=n347
XU891 NOR2BX1TR $PINS AN=n347 B=FE_OFN9_reset Y=n569
XU892 CLKINVX2TR $PINS A=n1355 Y=n551
XU893 INVX1TR $PINS A=n1350 Y=n348
XU894 NAND2X1TR $PINS A=n348 B=n1351 Y=n349
XU895 NOR2BX1TR $PINS AN=n350 B=FE_OFN0_FE_DBTN0_n2195 Y=n351
XU896 ADDFX2TR $PINS A=n354 B=n353 CI=n352 S=n1113 CO=n609
XU897 NAND2X1TR $PINS A=n610 B=n609 Y=PE_top0_DP_OP_17J1_122_4844_n32
XU898 OAI22X2TR $PINS A0=n806 A1=n360 B0=n812 B1=n359 Y=n372
XU899 NAND2BX1TR $PINS AN=n191 B=n1380 Y=n361
XU900 OAI22X2TR $PINS A0=n806 A1=n362 B0=n812 B1=n361 Y=n371
XU901 ADDFHX2TR $PINS A=n365 B=n364 CI=n363 S=n583 CO=n356
XU902 XNOR2X1TR $PINS A=n1382 B=n123 Y=n375
XU903 OAI22X1TR $PINS A0=n197 A1=n375 B0=n195 B1=n370 Y=n587
XU904 CMPR22X2TR $PINS A=n372 B=n371 S=n586 CO=n584
XU905 NOR2BX1TR $PINS AN=n191 B=n812 Y=n379
XU906 XNOR2X1TR $PINS A=n1384 B=n814 Y=n380
XU907 OAI22X1TR $PINS A0=n197 A1=n381 B0=n195 B1=n375 Y=n377
XU908 CLKINVX2TR $PINS A=n376 Y=n404
XU909 OAI22X1TR $PINS A0=n386 A1=n383 B0=n380 B1=n384 Y=n396
XU910 XNOR2X1TR $PINS A=n1382 B=n191 Y=n382
XU911 OAI22X1TR $PINS A0=n197 A1=n382 B0=n195 B1=n381 Y=n395
XU912 INVX1TR $PINS A=n388 Y=n389
XU913 ADDHX1TR $PINS A=n396 B=n395 S=n401 CO=n402
XU914 OAI22X1TR $PINS A0=n197 A1=n399 B0=n195 B1=n398 Y=n400
XU915 NAND2X1TR $PINS A=n403 B=n402 Y=n840
XU916 ADDFHX4TR $PINS A=n408 B=n407 CI=n406 S=n189 CO=n791
XU917 ADDFHX2TR $PINS A=n411 B=n410 CI=n409 S=n406 CO=n789
XU918 XNOR2X2TR $PINS A=n1357 B=n160 Y=n747
XU919 XNOR2X2TR $PINS A=n767 B=n766 Y=n788
XU920 XNOR2X1TR $PINS A=n1359 B=n414 Y=n744
XU921 CMPR22X2TR $PINS A=n419 B=n418 S=n408 CO=n771
XU922 ADDFHX2TR $PINS A=n423 B=n422 CI=n421 S=n428 CO=n154
XU923 ADDFHX2TR $PINS A=n426 B=n425 CI=n424 S=n329 CO=n427
XU924 NOR2X2TR $PINS A=n428 B=n427 Y=PE_top0_buff_mult_arr0_mult_x_33_n29
XU925 NAND2X1TR $PINS A=n432 B=n643 Y=n435
XU926 INVX2TR $PINS A=n429 Y=n430
XU927 OAI21X2TR $PINS A0=n435 A1=n434 B0=n433 Y=n645
XU928 NOR2X1TR $PINS A=n437 B=PE_top0_buff_mult_arr0_mult_x_33_n29 Y=n439
XU929 AOI21X2TR $PINS A0=n645 A1=n439 B0=n438
+ Y=PE_top0_buff_mult_arr0_mult_x_33_n1
XU930 NOR2BX1TR $PINS AN=FE_OCPN141_n162 B=FE_OCPN142_n157 Y=n447
XU931 OAI22X2TR $PINS A0=n453 A1=n449 B0=n443 B1=n454 Y=n446
XU932 XNOR2X1TR $PINS A=n1361 B=n159 Y=n450
XU933 OAI22X1TR $PINS A0=n760 A1=n450 B0=n169 B1=n444 Y=n445
XU934 ADDFHX2TR $PINS A=n447 B=n446 CI=n445 S=n474 CO=n475
XU935 XNOR2X1TR $PINS A=n1363 B=n160 Y=n452
XU936 OAI22X1TR $PINS A0=n453 A1=n452 B0=n449 B1=n454 Y=n466
XU937 OAI22X2TR $PINS A0=n760 A1=n451 B0=n169 B1=n450 Y=n465
XU938 NAND2X1TR $PINS A=n793 B=n785 Y=n479
XU939 INVX1TR $PINS A=n457 Y=n458
XU940 NOR2BX1TR $PINS AN=FE_OCPN141_n162 B=n169 Y=n460
XU941 NAND2BX1TR $PINS AN=FE_OCPN141_n162 B=n1361 Y=n468
XU942 OAI22X1TR $PINS A0=n760 A1=n469 B0=n169 B1=n468 Y=n470
XU943 OR2X2TR $PINS A=n471 B=n470 Y=n1127
XU944 NAND2X1TR $PINS A=n471 B=n470 Y=n1126
XU945 AOI21X1TR $PINS A0=n1128 A1=n1127 B0=n472 Y=n781
XU946 NAND2X1TR $PINS A=n474 B=n473 Y=n783
XU947 NAND2X1TR $PINS A=n476 B=n475 Y=n792
XU948 OA21X2TR $PINS A0=n477 A1=n783 B0=n792 Y=n478
XU949 OAI21X1TR $PINS A0=n479 A1=n781 B0=n478
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n32
XU950 OA21XLTR $PINS A0=n1387 A1=n1389 B0=n1392 Y=n482
XU951 NOR2BX1TR $PINS AN=n487 B=FE_OFN0_FE_DBTN0_n2195 Y=n488
XU952 NOR2BX2TR $PINS AN=n488 B=FE_OFN114_reset Y=n538
XU953 OAI21X1TR $PINS A0=n1336 A1=n1331 B0=n1332 Y=n491
XU954 CLKINVX2TR $PINS A=n1329 Y=n489
XU955 NAND2X1TR $PINS A=n489 B=n1330 Y=n490
XU956 XNOR2X1TR $PINS A=n491 B=n490 Y=n492
XU957 AND2X2TR $PINS A=n492 B=n1866 Y=n493
XU958 NOR2BX1TR $PINS AN=n493 B=FE_OFN114_reset Y=n537
XU959 AOI21X2TR $PINS A0=n1355 A1=n495 B0=n494 Y=n534
XU962 INVX1TR $PINS A=n1346 Y=n497
XU963 OR2X2TR $PINS A=n1331 B=n1329 Y=n504
XU964 OA21XLTR $PINS A0=n1329 A1=n1332 B0=n1330 Y=n503
XU965 OAI21X1TR $PINS A0=n504 A1=n1336 B0=n503 Y=n505
XU966 XNOR2X1TR $PINS A=n505 B=n1328 Y=n506
XU967 OAI21X1TR $PINS A0=n534 A1=n509 B0=n508 Y=n511
XU968 NAND2X1TR $PINS A=n1345 B=n1354 Y=n510
XU969 NAND2X1TR $PINS A=n518 B=n1392 Y=n519
XU970 XNOR2X1TR $PINS A=n520 B=n519 Y=n521
XU971 NOR2BX1TR $PINS AN=n521 B=FE_DBTN0_n2195 Y=n522
XU972 NAND2X1TR $PINS A=n523 B=n1373 Y=n524
XU973 NOR2BX1TR $PINS AN=n526 B=FE_OFN0_FE_DBTN0_n2195 Y=n527
XU974 NOR2BX2TR $PINS AN=n527 B=FE_OFN114_reset Y=n560
XU975 CLKINVX2TR $PINS A=n1331 Y=n528
XU976 NAND2X1TR $PINS A=n528 B=n1332 Y=n529
XU977 NOR2BX1TR $PINS AN=n531 B=FE_OFN114_reset Y=n559
XU978 NAND2X1TR $PINS A=n532 B=n1347 Y=n533
XU979 NOR2BX1TR $PINS AN=n535 B=FE_OFN114_reset Y=n558
XU980 ADDFHX2TR $PINS A=n538 B=n537 CI=n536 S=n858 CO=n517
XU981 INVX1TR $PINS A=n1388 Y=n540
XU982 NAND2X1TR $PINS A=n540 B=n1389 Y=n541
XU983 NOR2BX1TR $PINS AN=n542 B=FE_DBTN0_n2195 Y=n543
XU984 NOR2BX1TR $PINS AN=n543 B=FE_OFN9_reset Y=n863
XU985 OAI21X1TR $PINS A0=n544 A1=n1369 B0=n1370 Y=n545
XU986 NOR2BX1TR $PINS AN=n546 B=FE_OFN0_FE_DBTN0_n2195 Y=n547
XU987 NOR2BX4TR $PINS AN=n547 B=FE_OFN113_reset Y=n567
XU988 OAI21X1TR $PINS A0=n1327 A1=n1335 B0=n1334 Y=n548
XU989 XNOR2X1TR $PINS A=n548 B=n1333 Y=n549
XU990 NOR2BX1TR $PINS AN=n549 B=n1865 Y=n550
XU991 NOR2BX1TR $PINS AN=n550 B=FE_OFN9_reset Y=n566
XU992 OAI21X1TR $PINS A0=n551 A1=n1350 B0=n1351 Y=n554
XU993 INVX1TR $PINS A=n1348 Y=n552
XU994 NAND2X1TR $PINS A=n552 B=n1349 Y=n553
XU995 XNOR2X1TR $PINS A=n554 B=n553 Y=n556
XU996 NOR2BX1TR $PINS AN=n556 B=FE_OFN0_FE_DBTN0_n2195 Y=n557
XU997 NOR2BX1TR $PINS AN=n557 B=FE_OFN113_reset Y=n565
XU998 ADDFHX2TR $PINS A=n560 B=n559 CI=n558 S=n861 CO=n859
XU999 ADDFHX2TR $PINS A=n567 B=n566 CI=n565 S=n618 CO=n862
XU1000 CMPR32X2TR $PINS A=n570 B=n569 C=n568 S=n620 CO=n617
XU1001 NOR2X1TR $PINS A=n1109 B=n1108 Y=PE_top0_DP_OP_17J1_122_4844_n24
XU1002 XNOR2X1TR $PINS A=n1339 B=n573 Y=n720
XU1003 OAI22X2TR $PINS A0=n721 A1=n574 B0=n719 B1=n720 Y=n715
XU1004 XNOR2X1TR $PINS A=n1337 B=n663 Y=n711
XU1005 OAI22X2TR $PINS A0=n712 A1=n575 B0=n710 B1=n711 Y=n714
XU1006 INVX2TR $PINS A=n726 Y=n713
XU1007 ADDFHX2TR $PINS A=n580 B=n579 CI=n578 S=n581 CO=n729
XU1008 ADDFHX2TR $PINS A=n585 B=n584 CI=n583 S=n590 CO=n366
XU1009 ADDFHX2TR $PINS A=n588 B=n587 CI=n586 S=n373 CO=n589
XU1011 OAI22X1TR $PINS A0=n721 A1=n595 B0=n719 B1=n594 Y=n655
XU1012 OAI22X4TR $PINS A0=n721 A1=n596 B0=n719 B1=n595 Y=n605
XU1013 CLKINVX2TR $PINS A=n1339 Y=n598
XU1014 NAND2BX1TR $PINS AN=n266 B=n1339 Y=n597
XU1015 OAI22X2TR $PINS A0=n721 A1=n598 B0=n719 B1=n597 Y=n604
XU1016 ADDFHX1TR $PINS A=n601 B=n600 CI=n599 S=n653 CO=n651
XU1017 XNOR2X1TR $PINS A=n1343 B=n708 Y=n664
XU1018 OAI22X1TR $PINS A0=n264 A1=n664 B0=n602 B1=n677 Y=n660
XU1019 XNOR2X1TR $PINS A=n1341 B=n669 Y=n665
XU1020 OAI22X2TR $PINS A0=n259 A1=n665 B0=n257 B1=n603 Y=n661
XU1021 CMPR22X2TR $PINS A=n605 B=n604 S=n662 CO=n654
XU1022 NAND2X1TR $PINS A=n659 B=n658 Y=PE_top0_buff_mult_arr0_mult_x_30_n30
XU1023 NOR2X1TR $PINS A=n610 B=n609 Y=PE_top0_DP_OP_17J1_122_4844_n31
XU1024 NAND2X1TR $PINS A=n1781 B=n1804 Y=n867
XU1025 NAND2X1TR $PINS A=n1784 B=n2230 Y=n1061
XU1026 NAND2X1TR $PINS A=n1785 B=n1806 Y=n871
XU1027 OR2X2TR $PINS A=n1786 B=n2231 Y=n1068
XU1028 INVX1TR $PINS A=n1067 Y=n611
XU1029 NOR2X1TR $PINS A=n1787 B=n1807 Y=n873
XU1030 NAND2X1TR $PINS A=n1787 B=n1807 Y=n874
XU1031 NAND2X1TR $PINS A=n1788 B=n2232 Y=n612
XU1032 NAND2X1TR $PINS A=n613 B=n612 Y=n614
XU1033 ADDFHX2TR $PINS A=n619 B=n618 CI=n617 S=n1111 CO=n1108
XU1034 ADDFX2TR $PINS A=n622 B=n621 CI=n620 S=n610 CO=n1110
XU1035 NOR2X1TR $PINS A=n1111 B=n1110 Y=PE_top0_DP_OP_17J1_122_4844_n27
XU1036 ADDFHX1TR $PINS A=n625 B=n624 CI=n623 S=n647 CO=n253
XU1037 ADDFHX2TR $PINS A=n627 B=n628 CI=n626 S=n637 CO=n636
XU1038 XNOR2X1TR $PINS A=n630 B=n629 Y=n635
XU1039 ADDFHX2TR $PINS A=n633 B=n632 CI=n631 S=n634 CO=n623
XU1040 ADDFHX1TR $PINS A=n636 B=n635 CI=n634 S=n641 CO=n646
XU1041 ADDFHX4TR $PINS A=n639 B=n638 CI=n637 S=n155 CO=n640
XU1042 NOR2X1TR $PINS A=n641 B=n640 Y=PE_top0_buff_mult_arr0_mult_x_33_n22
XU1043 NAND2X1TR $PINS A=n641 B=n640 Y=PE_top0_buff_mult_arr0_mult_x_33_n23
XU1044 NAND2X1TR $PINS A=n643 B=n642 Y=n644
XU1045 XNOR2X1TR $PINS A=n5 B=n644
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<4>
XU1046 INVX2TR $PINS A=n645 Y=PE_top0_buff_mult_arr0_mult_x_33_n31
XU1047 NAND2X1TR $PINS A=n657 B=n656 Y=PE_top0_buff_mult_arr0_mult_x_30_n27
XU1048 NOR2BX1TR $PINS AN=n266 B=n719 Y=n668
XU1049 XNOR2X1TR $PINS A=n663 B=n1343 Y=n671
XU1050 OAI22X2TR $PINS A0=n264 A1=n671 B0=n664 B1=n677 Y=n667
XU1051 XNOR2X1TR $PINS A=n1341 B=n262 Y=n672
XU1052 OAI22X1TR $PINS A0=n259 A1=n672 B0=n257 B1=n665 Y=n666
XU1053 ADDFHX1TR $PINS A=n668 B=n667 CI=n666 S=n698 CO=n699
XU1054 XNOR2X1TR $PINS A=n1343 B=n669 Y=n676
XU1055 OAI22X1TR $PINS A0=n264 A1=n676 B0=n671 B1=n677 Y=n689
XU1056 CLKINVX2TR $PINS A=n672 Y=n673
XU1057 OAI2BB2X2TR $PINS A0N=n674 A1N=n673 B0=n259 B1=n675 Y=n688
XU1058 OAI22X1TR $PINS A0=n264 A1=n266 B0=n262 B1=n677 Y=n682
XU1059 NAND2BX1TR $PINS AN=n266 B=n1343 Y=n680
XU1060 INVX1TR $PINS A=n680 Y=n681
XU1061 NAND2X1TR $PINS A=n684 B=n683 Y=n685
XU1062 OAI21X1TR $PINS A0=n687 A1=n686 B0=n685 Y=n1133
XU1063 ADDHX1TR $PINS A=n689 B=n688 S=n695 CO=n697
XU1064 CLKINVX2TR $PINS A=n1341 Y=n693
XU1065 OAI22X1TR $PINS A0=n259 A1=n693 B0=n257 B1=n692 Y=n694
XU1066 NAND2X1TR $PINS A=n695 B=n694 Y=n1131
XU1067 INVX2TR $PINS A=n1131 Y=n696
XU1068 AOI21X4TR $PINS A0=n1133 A1=n1132 B0=n696 Y=n703
XU1069 NAND2X1TR $PINS A=n698 B=n697 Y=n704
XU1070 AOI21X1TR $PINS A0=n736 A1=n732 B0=n700 Y=n701
XU1071 OAI21X1TR $PINS A0=n702 A1=n703 B0=n701
+ Y=PE_top0_buff_mult_arr0_mult_x_30_n32
XU1072 INVX2TR $PINS A=n703 Y=n734
XU1073 NAND2X1TR $PINS A=n733 B=n704 Y=n705
XU1074 XNOR2X1TR $PINS A=n734 B=n705
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<4>
XU1075 XNOR2X1TR $PINS A=n1337 B=n708 Y=n709
XU1076 OAI22X1TR $PINS A0=n712 A1=n711 B0=n710 B1=n709 Y=n728
XU1077 ADDFHX2TR $PINS A=n715 B=n714 CI=n713 S=n730 CO=n727
XU1078 XNOR2X1TR $PINS A=n1339 B=n716 Y=n718
XU1079 ADDFHX2TR $PINS A=n731 B=n730 CI=n729 S=n707 CO=n738
XU1080 XNOR2X1TR $PINS A=n1357 B=n740 Y=n745
XU1081 XNOR2X1TR $PINS A=n1357 B=n414 Y=n742
XU1082 OAI22X1TR $PINS A0=n748 A1=n745 B0=n746 B1=n742 Y=n765
XU1083 XNOR2X1TR $PINS A=n1359 B=n743 Y=n756
XU1084 OAI22X4TR $PINS A0=n757 A1=n744 B0=FE_OCPN142_n157 B1=n756 Y=n770
XU1085 OAI22X4TR $PINS A0=n748 A1=n747 B0=n746 B1=n745 Y=n769
XU1086 OAI22X1TR $PINS A0=n757 A1=n756 B0=n754 B1=FE_OCPN142_n157 Y=n762
XU1087 ADDFHX4TR $PINS A=n770 B=n769 CI=n768 S=n778 CO=n764
XU1088 NAND2X1TR $PINS A=n776 B=n775 Y=PE_top0_buff_mult_arr0_mult_x_27_n2
XU1089 NOR2X1TR $PINS A=n780 B=n779 Y=PE_top0_buff_mult_arr0_mult_x_27_n29
XU1090 NAND2X1TR $PINS A=n785 B=n783 Y=n782
XU1091 XNOR2X1TR $PINS A=n786 B=n782
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out_int_4_
XU1092 INVX1TR $PINS A=n783 Y=n784
XU1093 AOI21X1TR $PINS A0=n786 A1=n785 B0=n784
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n39
XU1094 OAI22X1TR $PINS A0=n197 A1=n801 B0=n195 B1=n807 Y=n816
XU1095 XNOR2X1TR $PINS A=n1380 B=n804 Y=n805
XU1096 OAI22X1TR $PINS A0=n806 A1=n811 B0=n812 B1=n805 Y=n810
XU1097 AO21X1TR $PINS A0=n197 A1=n195 B0=n807 Y=n809
XU1098 CLKINVX2TR $PINS A=n816 Y=n825
XU1099 XNOR2X1TR $PINS A=n1378 B=n817 Y=n818
XU1100 OAI22X1TR $PINS A0=n821 A1=n820 B0=n819 B1=n818 Y=n822
XU1101 ADDFHX2TR $PINS A=n827 B=n826 CI=n825 S=n833 CO=n823
XU1102 ADDFX2TR $PINS A=n830 B=n829 CI=n828 S=n835 CO=n832
XU1103 ADDFHX2TR $PINS A=n834 B=n833 CI=n832 S=n847 CO=n831
XU1104 ADDFHX2TR $PINS A=n837 B=n836 CI=n835 S=n838 CO=n846
XU1105 NAND2X1TR $PINS A=n839 B=n838 Y=PE_top0_buff_mult_arr0_mult_x_24_n23
XU1106 NAND2X1TR $PINS A=n841 B=n840 Y=n842
XU1107 XNOR2X1TR $PINS A=n843 B=n842
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out_int_4_
XU1108 NAND2X1TR $PINS A=n845 B=n844 Y=PE_top0_buff_mult_arr0_mult_x_24_n7
XU1109 OAI21X1TR $PINS A0=n1771 A1=n1774 B0=n1772 Y=n849
XU1110 AOI21X1TR $PINS A0=n850 A1=n1760 B0=n849 Y=n1160
XU1111 NAND2X1TR $PINS A=n1156 B=n1871 Y=n853
XU1112 OAI21X1TR $PINS A0=n1767 A1=n1770 B0=n1768 Y=n1157
XU1113 AOI21X1TR $PINS A0=n1157 A1=n1871 B0=n851 Y=n852
XU1114 OAI21X1TR $PINS A0=n1160 A1=n853 B0=n852 Y=n854
XU1115 XNOR2X1TR $PINS A=n854 B=n1765 Y=n855
XU1116 NOR2BX1TR $PINS AN=n855 B=FE_OFN117_n Y=PE_top0_OUT_ADD<7>
XU1117 NOR2BX1TR $PINS AN=n857 B=FE_OFN117_n Y=pe_out_pk_data__0_
XU1119 AND2X1TR $PINS A=n1821 B=FE_OFN118_n Y=pe_out_pk_PE_state__1_
XU1120 AND2X1TR $PINS A=n1820 B=FE_OFN118_n Y=pe_out_pk_PE_state__2_
XU1121 AND2X1TR $PINS A=n1823 B=n1795 Y=pk_out_data__3_
XU1122 AND2X1TR $PINS A=n1823 B=n1789 Y=pk_out_data__0_
XU1123 AND2X1TR $PINS A=n1823 B=n1791 Y=pk_out_data__1_
XU1124 AND2X1TR $PINS A=n1823 B=n1801 Y=pk_out_data__6_
XU1125 AND2X1TR $PINS A=n1823 B=n1799 Y=pk_out_data__5_
XU1126 AND2X1TR $PINS A=n1823 B=n1797 Y=pk_out_data__4_
XU1127 AND2X1TR $PINS A=n1823 B=n1793 Y=pk_out_data__2_
XU1128 ADDFHX2TR $PINS A=n860 B=n859 CI=n858 S=n865 CO=n539
XU1129 ADDFHX1TR $PINS A=n863 B=n862 CI=n861 S=n1109 CO=n864
XU1130 AO22X1TR $PINS A0=n878 A1=n866 B0=n616 B1=n1804 Y=n1396
XU1131 AFHCINX2TR $PINS A=n1805 B=n1782 CIN=n867 S=n868 CO=n1056
XU1132 AO22X1TR $PINS A0=n878 A1=n869 B0=n616 B1=n1805 Y=n1397
XU1133 INVX1TR $PINS A=n873 Y=n875
XU1135 CLKINVX2TR $PINS A=pe_in_pk_wrb_addr__0_ Y=n893
XU1136 OAI31X4TR $PINS A0=pe_in_pk_wrb_addr__2_ A1=pe_in_pk_wrb_addr__0_
+ A2=pe_in_pk_wrb_addr__1_ B0=pe_in_pk_wrb_addr__3_ Y=n914
XU1137 NAND2X2TR $PINS A=pe_in_pk_wrb__3_ B=n914 Y=n879
XU1138 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN33_n881 B0=n1015 B1=n1872
+ Y=n1400
XU1140 AO22X1TR $PINS A0=n882 A1=FE_OFN34_n881 B0=n1017 B1=n1873 Y=n1401
XU1141 AO22X1TR $PINS A0=n883 A1=FE_OFN33_n881 B0=n1025 B1=n1874 Y=n1402
XU1142 AO22X1TR $PINS A0=n884 A1=FE_OFN33_n881 B0=n1019 B1=n1875 Y=n1403
XU1143 NAND2X2TR $PINS A=pe_in_pk_wrb__0_ B=n914 Y=n902
XU1144 AO22X1TR $PINS A0=n1032 A1=FE_OFN97_n881 B0=FE_OFN57_n886 B1=n1876
+ Y=n1404
XU1145 AO22X1TR $PINS A0=FE_OFN137_n887 A1=FE_OFN97_n881 B0=n1034 B1=n1877
+ Y=n1405
XU1147 AO22X1TR $PINS A0=n888 A1=FE_OFN97_n881 B0=n10 B1=n1878 Y=n1406
XU1148 AO22X1TR $PINS A0=n889 A1=FE_OFN97_n881 B0=n1037 B1=n1879 Y=n1407
XU1149 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN97_n881 B0=n1039 B1=n1880
+ Y=n1408
XU1150 AO22X1TR $PINS A0=FE_OFN76_n891 A1=FE_OFN97_n881 B0=n1041 B1=n1881
+ Y=n1409
XU1151 CLKINVX6TR $PINS A=pe_in_pk_wrb_addr__3_ Y=n946
XU1153 INVX4TR $PINS A=n896 Y=n1043
XU1154 AO22X1TR $PINS A0=n896 A1=FE_OFN33_n881 B0=n1043 B1=n1882 Y=n1410
XU1155 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=pe_in_pk_wrb_addr__0_
+ C=pe_in_pk_wrb_addr__1_ Y=n936
XU1156 OAI21X1TR $PINS A0=FE_OCPN143_n879 A1=n936 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n900
XU1157 INVX4TR $PINS A=n900 Y=n1021
XU1158 AO22X1TR $PINS A0=FE_PSN237_n900 A1=FE_OFN33_n881 B0=n1021 B1=n1883
+ Y=n1411
XU1160 AO22X1TR $PINS A0=n903 A1=FE_OFN97_n881 B0=n978 B1=n1884 Y=n1412
XU1161 OAI21X1TR $PINS A0=n936 A1=n902 B0=FE_OFN32_FE_DBTN1_reset Y=n904
XU1164 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN97_n881 B0=n1045 B1=n1885
+ Y=n1413
XU1165 INVX2TR $PINS A=n906 Y=n1023
XU1166 AO22X1TR $PINS A0=n906 A1=FE_OFN33_n881 B0=n1023 B1=n1887 Y=n1414
XU1167 OAI21X2TR $PINS A0=n946 A1=n902 B0=FE_OFN32_FE_DBTN1_reset Y=n908
XU1168 INVX2TR $PINS A=n908 Y=n1047
XU1169 AO22X1TR $PINS A0=n908 A1=FE_OFN97_n881 B0=n1047 B1=n1889 Y=n1415
XU1170 NAND2X2TR $PINS A=pe_in_pk_wrb__1_ B=n914 Y=n945
XU1171 OAI21X1TR $PINS A0=n920 A1=n945 B0=FE_OFN32_FE_DBTN1_reset Y=n909
XU1173 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN97_n881 B0=n986 B1=n1890
+ Y=n1416
XU1174 OAI21X1TR $PINS A0=n922 A1=n945 B0=FE_OFN116_n Y=n910
XU1175 OAI21X2TR $PINS A0=n924 A1=n945 B0=FE_OFN116_n Y=n911
XU1177 AO22X1TR $PINS A0=n911 A1=FE_OFN34_n881 B0=n990 B1=n1892 Y=n1418
XU1178 OAI21X1TR $PINS A0=n929 A1=n945 B0=FE_OFN32_FE_DBTN1_reset Y=n912
XU1179 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN97_n881 B0=n992 B1=n1893
+ Y=n1419
XU1180 OAI21X1TR $PINS A0=n932 A1=n945 B0=FE_OFN32_FE_DBTN1_reset Y=n913
XU1182 AO22X1TR $PINS A0=FE_OFN102_n913 A1=FE_OFN97_n881 B0=n994 B1=n1894
+ Y=n1420
XU1183 NAND2X2TR $PINS A=pe_in_pk_wrb__2_ B=n914 Y=n915
XU1185 OAI21X1TR $PINS A0=n936 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n916
XU1188 AO22X1TR $PINS A0=n916 A1=FE_OFN33_n881 B0=FE_OFN63_n916 B1=n1895
+ Y=n1421
XU1189 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN33_n881 B0=n1000 B1=n1896
+ Y=n1422
XU1190 OAI21X1TR $PINS A0=n885 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n918
XU1191 AO22X1TR $PINS A0=n918 A1=FE_OFN34_n881 B0=n1003 B1=n1897 Y=n1423
XU1192 OAI21X1TR $PINS A0=n920 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n921
XU1193 AO22X1TR $PINS A0=FE_OFN123_n921 A1=FE_OFN34_n881 B0=FE_OFN81_n921
+ B1=n1898 Y=n1424
XU1195 OAI21X1TR $PINS A0=n924 A1=FE_PSBN144_n915 B0=FE_OFN31_FE_DBTN1_reset
+ Y=n925
XU1197 AO22X1TR $PINS A0=n925 A1=FE_OFN34_n881 B0=n1009 B1=n1900 Y=n1426
XU1198 OAI21X2TR $PINS A0=n929 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n927
XU1199 AO22X1TR $PINS A0=n927 A1=FE_OFN34_n881 B0=n1011 B1=n1901 Y=n1427
XU1200 OAI21X2TR $PINS A0=n932 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n928
XU1201 AO22X1TR $PINS A0=n928 A1=FE_OFN34_n881 B0=n1013 B1=n1902 Y=n1428
XU1202 AO22X1TR $PINS A0=n930 A1=FE_OFN33_n881 B0=n1028 B1=n1903 Y=n1429
XU1203 AO22X1TR $PINS A0=n933 A1=FE_OFN33_n881 B0=n1030 B1=n1904 Y=n1430
XU1204 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN33_n881 B0=n998 B1=n1906
+ Y=n1431
XU1205 OAI21X1TR $PINS A0=n936 A1=n945 B0=FE_OFN116_n Y=n937
XU1208 AO22X1TR $PINS A0=FE_PSN238_n937 A1=FE_OFN34_n881 B0=n980 B1=n1907
+ Y=n1432
XU1209 OAI21X1TR $PINS A0=n895 A1=n945 B0=FE_OFN116_n Y=n939
XU1212 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN34_n881 B0=n984 B1=n1908
+ Y=n1433
XU1213 OAI21X1TR $PINS A0=n885 A1=n945 B0=FE_OFN27_FE_DBTN1_reset Y=n943
XU1214 AO22X1TR $PINS A0=FE_OFN134_n943 A1=FE_OFN34_n881 B0=n982 B1=n1909
+ Y=n1434
XU1215 AO22X1TR $PINS A0=FE_OFN68_n947 A1=FE_OFN97_n881 B0=n996 B1=n1911
+ Y=n1435
XU1216 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN35_n949 B0=n1015 B1=n1912
+ Y=n1436
XU1217 AO22X1TR $PINS A0=n882 A1=FE_OFN35_n949 B0=n1017 B1=n1913 Y=n1437
XU1218 AO22X1TR $PINS A0=n883 A1=n949 B0=n1025 B1=n1914 Y=n1438
XU1219 AO22X1TR $PINS A0=n884 A1=n949 B0=n1019 B1=n1915 Y=n1439
XU1220 AO22X1TR $PINS A0=n1032 A1=FE_OFN73_n949 B0=FE_OFN57_n886 B1=n1916
+ Y=n1440
XU1221 AO22X1TR $PINS A0=FE_OFN139_n887 A1=FE_OFN73_n949 B0=n1034 B1=n1917
+ Y=n1441
XU1222 AO22X1TR $PINS A0=n888 A1=FE_OFN73_n949 B0=n10 B1=n1918 Y=n1442
XU1223 AO22X1TR $PINS A0=n889 A1=FE_OFN73_n949 B0=n1037 B1=n1919 Y=n1443
XU1224 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN73_n949 B0=n1039 B1=n1920
+ Y=n1444
XU1225 AO22X1TR $PINS A0=FE_OFN77_n891 A1=FE_OFN73_n949 B0=n1041 B1=n1921
+ Y=n1445
XU1226 AO22X1TR $PINS A0=n896 A1=n949 B0=n1043 B1=n1922 Y=n1446
XU1227 AO22X1TR $PINS A0=FE_PSN237_n900 A1=n949 B0=n1021 B1=n1923 Y=n1447
XU1228 AO22X1TR $PINS A0=n903 A1=FE_OFN73_n949 B0=n978 B1=n1924 Y=n1448
XU1229 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN73_n949 B0=n1045 B1=n1925
+ Y=n1449
XU1230 AO22X1TR $PINS A0=n906 A1=FE_OFN35_n949 B0=n1023 B1=n1927 Y=n1450
XU1231 AO22X1TR $PINS A0=n908 A1=FE_OFN72_n949 B0=n1047 B1=n1929 Y=n1451
XU1232 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN73_n949 B0=n986 B1=n1930
+ Y=n1452
XU1233 AO22X1TR $PINS A0=n911 A1=FE_OFN73_n949 B0=n990 B1=n1932 Y=n1454
XU1234 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN73_n949 B0=n992 B1=n1933
+ Y=n1455
XU1235 AO22X1TR $PINS A0=FE_OFN102_n913 A1=FE_OFN72_n949 B0=n994 B1=n1934
+ Y=n1456
XU1236 AO22X1TR $PINS A0=n916 A1=FE_OFN35_n949 B0=FE_OFN63_n916 B1=n1935
+ Y=n1457
XU1237 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN35_n949 B0=n1000 B1=n1936
+ Y=n1458
XU1238 AO22X1TR $PINS A0=n918 A1=FE_OFN35_n949 B0=n1003 B1=n1937 Y=n1459
XU1239 AO22X1TR $PINS A0=FE_OFN125_n921 A1=FE_OFN35_n949 B0=FE_OFN81_n921
+ B1=n1938 Y=n1460
XU1240 AO22X1TR $PINS A0=n925 A1=FE_OFN35_n949 B0=n1009 B1=n1940 Y=n1462
XU1241 AO22X1TR $PINS A0=n927 A1=FE_OFN35_n949 B0=n1011 B1=n1941 Y=n1463
XU1242 AO22X1TR $PINS A0=n928 A1=FE_OFN35_n949 B0=n1013 B1=n1942 Y=n1464
XU1243 AO22X1TR $PINS A0=n930 A1=FE_OFN35_n949 B0=n1028 B1=n1943 Y=n1465
XU1244 AO22X1TR $PINS A0=n933 A1=FE_OFN35_n949 B0=n1030 B1=n1944 Y=n1466
XU1245 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN35_n949 B0=n998 B1=n1946
+ Y=n1467
XU1246 AO22X1TR $PINS A0=FE_PSN238_n937 A1=FE_OFN73_n949 B0=n980 B1=n1947
+ Y=n1468
XU1247 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN73_n949 B0=n984 B1=n1948
+ Y=n1469
XU1248 AO22X1TR $PINS A0=FE_OFN134_n943 A1=FE_OFN73_n949 B0=n982 B1=n1949
+ Y=n1470
XU1249 AO22X1TR $PINS A0=FE_OFN67_n947 A1=FE_OFN72_n949 B0=n996 B1=n1951
+ Y=n1471
XU1250 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__5_ B=FE_OFN8_reset Y=n955
XU1252 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN37_n955 B0=n1015 B1=n1952
+ Y=n1472
XU1253 AO22X1TR $PINS A0=n882 A1=FE_OFN37_n955 B0=n1017 B1=n1953 Y=n1473
XU1254 AO22X1TR $PINS A0=n883 A1=n955 B0=n1025 B1=n1954 Y=n1474
XU1255 AO22X1TR $PINS A0=n884 A1=n955 B0=n1019 B1=n1955 Y=n1475
XU1256 AO22X1TR $PINS A0=n1032 A1=FE_OFN94_n955 B0=FE_OFN57_n886 B1=n1956
+ Y=n1476
XU1257 AO22X1TR $PINS A0=FE_OFN138_n887 A1=FE_OFN94_n955 B0=n1034 B1=n1957
+ Y=n1477
XU1258 AO22X1TR $PINS A0=n888 A1=FE_OFN94_n955 B0=n10 B1=n1958 Y=n1478
XU1259 AO22X1TR $PINS A0=n889 A1=FE_OFN94_n955 B0=n1037 B1=n1959 Y=n1479
XU1260 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN94_n955 B0=n1039 B1=n1960
+ Y=n1480
XU1261 AO22X1TR $PINS A0=FE_OFN78_n891 A1=FE_OFN94_n955 B0=n1041 B1=n1961
+ Y=n1481
XU1262 AO22X1TR $PINS A0=n896 A1=FE_OFN37_n955 B0=n1043 B1=n1962 Y=n1482
XU1263 AO22X1TR $PINS A0=FE_PSN237_n900 A1=n955 B0=n1021 B1=n1963 Y=n1483
XU1265 AO22X1TR $PINS A0=n903 A1=FE_OFN94_n955 B0=n978 B1=n1964 Y=n1484
XU1266 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN94_n955 B0=n1045 B1=n1965
+ Y=n1485
XU1267 AO22X1TR $PINS A0=n906 A1=FE_OFN37_n955 B0=n1023 B1=n1967 Y=n1486
XU1268 AO22X1TR $PINS A0=n908 A1=FE_OFN94_n955 B0=n1047 B1=n1969 Y=n1487
XU1269 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN93_n955 B0=n986 B1=n1970
+ Y=n1488
XU1270 AO22X1TR $PINS A0=n911 A1=FE_OFN93_n955 B0=n990 B1=n1972 Y=n1490
XU1271 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN93_n955 B0=n992 B1=n1973
+ Y=n1491
XU1272 AO22X1TR $PINS A0=FE_OFN102_n913 A1=FE_OFN94_n955 B0=n994 B1=n1974
+ Y=n1492
XU1273 AO22X1TR $PINS A0=n916 A1=FE_OFN37_n955 B0=FE_OFN63_n916 B1=n1975
+ Y=n1493
XU1274 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN37_n955 B0=n1000 B1=n1976
+ Y=n1494
XU1275 AO22X1TR $PINS A0=n918 A1=FE_OFN37_n955 B0=n1003 B1=n1977 Y=n1495
XU1277 AO22X1TR $PINS A0=FE_OFN126_n921 A1=FE_OFN37_n955 B0=FE_OFN81_n921
+ B1=n1978 Y=n1496
XU1278 AO22X1TR $PINS A0=FE_PSN236_n925 A1=FE_OFN37_n955 B0=n1009 B1=n1980
+ Y=n1498
XU1279 AO22X1TR $PINS A0=n927 A1=FE_OFN37_n955 B0=n1011 B1=n1981 Y=n1499
XU1280 AO22X1TR $PINS A0=n928 A1=FE_OFN37_n955 B0=n1013 B1=n1982 Y=n1500
XU1281 AO22X1TR $PINS A0=n930 A1=FE_OFN37_n955 B0=n1028 B1=n1983 Y=n1501
XU1282 AO22X1TR $PINS A0=n933 A1=FE_OFN37_n955 B0=n1030 B1=n1984 Y=n1502
XU1283 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN37_n955 B0=n998 B1=n1986
+ Y=n1503
XU1284 AO22X1TR $PINS A0=FE_PSN238_n937 A1=FE_OFN93_n955 B0=n980 B1=n1987
+ Y=n1504
XU1285 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN93_n955 B0=n984 B1=n1988
+ Y=n1505
XU1286 AO22X1TR $PINS A0=FE_OFN134_n943 A1=FE_OFN93_n955 B0=n982 B1=n1989
+ Y=n1506
XU1287 AO22X1TR $PINS A0=FE_OFN67_n947 A1=FE_OFN94_n955 B0=n996 B1=n1991
+ Y=n1507
XU1288 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__4_ B=FE_OFN8_reset Y=n959
XU1290 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN40_n959 B0=n1015 B1=n1992
+ Y=n1508
XU1291 AO22X1TR $PINS A0=n882 A1=FE_OFN40_n959 B0=n1017 B1=n1993 Y=n1509
XU1292 AO22X1TR $PINS A0=n883 A1=FE_OFN39_n959 B0=n1025 B1=n1994 Y=n1510
XU1293 AO22X1TR $PINS A0=n884 A1=FE_OFN39_n959 B0=n1019 B1=n1995 Y=n1511
XU1294 AO22X1TR $PINS A0=n1032 A1=FE_OFN85_n959 B0=FE_OFN57_n886 B1=n1996
+ Y=n1512
XU1295 AO22X1TR $PINS A0=FE_OFN140_n887 A1=FE_OFN85_n959 B0=n1034 B1=n1997
+ Y=n1513
XU1296 AO22X1TR $PINS A0=n888 A1=FE_OFN85_n959 B0=n10 B1=n1998 Y=n1514
XU1297 AO22X1TR $PINS A0=n889 A1=FE_OFN85_n959 B0=n1037 B1=n1999 Y=n1515
XU1298 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN85_n959 B0=n1039 B1=n2000
+ Y=n1516
XU1299 AO22X1TR $PINS A0=FE_OFN78_n891 A1=FE_OFN85_n959 B0=n1041 B1=n2001
+ Y=n1517
XU1300 AO22X1TR $PINS A0=n896 A1=FE_OFN39_n959 B0=n1043 B1=n2002 Y=n1518
XU1301 AO22X1TR $PINS A0=FE_PSN237_n900 A1=FE_OFN39_n959 B0=n1021 B1=n2003
+ Y=n1519
XU1303 AO22X1TR $PINS A0=n903 A1=FE_OFN85_n959 B0=n978 B1=n2004 Y=n1520
XU1304 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN85_n959 B0=n1045 B1=n2005
+ Y=n1521
XU1305 AO22X1TR $PINS A0=n906 A1=FE_OFN39_n959 B0=n1023 B1=n2007 Y=n1522
XU1306 AO22X1TR $PINS A0=n908 A1=FE_OFN85_n959 B0=n1047 B1=n2009 Y=n1523
XU1307 AO22X1TR $PINS A0=FE_OFN106_n909 A1=FE_OFN85_n959 B0=n986 B1=n2010
+ Y=n1524
XU1308 AO22X1TR $PINS A0=n911 A1=FE_OFN85_n959 B0=n990 B1=n2012 Y=n1526
XU1309 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN85_n959 B0=n992 B1=n2013
+ Y=n1527
XU1310 AO22X1TR $PINS A0=FE_OFN98_n913 A1=FE_OFN40_n959 B0=n994 B1=n2014
+ Y=n1528
XU1311 AO22X1TR $PINS A0=n916 A1=FE_OFN40_n959 B0=FE_OFN63_n916 B1=n2015
+ Y=n1529
XU1312 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN40_n959 B0=n1000 B1=n2016
+ Y=n1530
XU1313 AO22X1TR $PINS A0=n918 A1=FE_OFN40_n959 B0=n1003 B1=n2017 Y=n1531
XU1315 AO22X1TR $PINS A0=FE_OFN126_n921 A1=FE_OFN40_n959 B0=FE_OFN81_n921
+ B1=n2018 Y=n1532
XU1316 AO22X1TR $PINS A0=n925 A1=FE_OFN40_n959 B0=n1009 B1=n2020 Y=n1534
XU1317 AO22X1TR $PINS A0=n927 A1=FE_OFN40_n959 B0=n1011 B1=n2021 Y=n1535
XU1318 AO22X1TR $PINS A0=n928 A1=FE_OFN40_n959 B0=n1013 B1=n2022 Y=n1536
XU1319 AO22X1TR $PINS A0=n930 A1=FE_OFN40_n959 B0=n1028 B1=n2023 Y=n1537
XU1320 AO22X1TR $PINS A0=n933 A1=FE_OFN39_n959 B0=n1030 B1=n2024 Y=n1538
XU1321 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN40_n959 B0=n998 B1=n2026
+ Y=n1539
XU1322 AO22X1TR $PINS A0=n937 A1=FE_OFN85_n959 B0=n980 B1=n2027 Y=n1540
XU1323 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN85_n959 B0=n984 B1=n2028
+ Y=n1541
XU1324 AO22X1TR $PINS A0=FE_OFN132_n943 A1=FE_OFN85_n959 B0=n982 B1=n2029
+ Y=n1542
XU1325 AO22X1TR $PINS A0=FE_OFN66_n947 A1=FE_OFN40_n959 B0=n996 B1=n2031
+ Y=n1543
XU1326 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__3_ B=FE_OFN8_reset Y=n963
XU1328 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN41_n963 B0=n1015 B1=n2032
+ Y=n1544
XU1329 AO22X1TR $PINS A0=n882 A1=FE_OFN41_n963 B0=n1017 B1=n2033 Y=n1545
XU1330 AO22X1TR $PINS A0=n883 A1=FE_OFN42_n963 B0=n1025 B1=n2034 Y=n1546
XU1331 AO22X1TR $PINS A0=n884 A1=FE_OFN42_n963 B0=n1019 B1=n2035 Y=n1547
XU1332 AO22X1TR $PINS A0=n1032 A1=FE_OFN88_n963 B0=FE_OFN57_n886 B1=n2036
+ Y=n1548
XU1333 AO22X1TR $PINS A0=FE_OFN140_n887 A1=FE_OFN88_n963 B0=n1034 B1=n2037
+ Y=n1549
XU1334 AO22X1TR $PINS A0=n888 A1=FE_OFN88_n963 B0=n10 B1=n2038 Y=n1550
XU1335 AO22X1TR $PINS A0=n889 A1=FE_OFN88_n963 B0=n1037 B1=n2039 Y=n1551
XU1336 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN88_n963 B0=n1039 B1=n2040
+ Y=n1552
XU1337 AO22X1TR $PINS A0=FE_OFN78_n891 A1=FE_OFN88_n963 B0=n1041 B1=n2041
+ Y=n1553
XU1338 AO22X1TR $PINS A0=n896 A1=FE_OFN42_n963 B0=n1043 B1=n2042 Y=n1554
XU1339 AO22X1TR $PINS A0=n900 A1=FE_OFN42_n963 B0=n1021 B1=n2043 Y=n1555
XU1340 AO22X1TR $PINS A0=n903 A1=FE_OFN88_n963 B0=n978 B1=n2044 Y=n1556
XU1341 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN88_n963 B0=n1045 B1=n2045
+ Y=n1557
XU1342 AO22X1TR $PINS A0=n906 A1=FE_OFN41_n963 B0=n1023 B1=n2047 Y=n1558
XU1343 AO22X1TR $PINS A0=n908 A1=FE_OFN88_n963 B0=n1047 B1=n2049 Y=n1559
XU1344 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN87_n963 B0=n986 B1=n2050
+ Y=n1560
XU1345 AO22X1TR $PINS A0=n911 A1=FE_OFN87_n963 B0=n990 B1=n2052 Y=n1562
XU1346 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN87_n963 B0=n992 B1=n2053
+ Y=n1563
XU1347 AO22X1TR $PINS A0=FE_OFN102_n913 A1=FE_OFN88_n963 B0=n994 B1=n2054
+ Y=n1564
XU1348 AO22X1TR $PINS A0=n916 A1=FE_OFN41_n963 B0=FE_OFN63_n916 B1=n2055
+ Y=n1565
XU1349 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN41_n963 B0=n1000 B1=n2056
+ Y=n1566
XU1350 AO22X1TR $PINS A0=n918 A1=FE_OFN42_n963 B0=n1003 B1=n2057 Y=n1567
XU1352 AO22X1TR $PINS A0=FE_OFN124_n921 A1=FE_OFN42_n963 B0=FE_OFN81_n921
+ B1=n2058 Y=n1568
XU1353 AO22X1TR $PINS A0=n925 A1=FE_OFN42_n963 B0=n1009 B1=n2060 Y=n1570
XU1354 AO22X1TR $PINS A0=n927 A1=FE_OFN41_n963 B0=n1011 B1=n2061 Y=n1571
XU1355 AO22X1TR $PINS A0=n928 A1=FE_OFN41_n963 B0=n1013 B1=n2062 Y=n1572
XU1356 AO22X1TR $PINS A0=n930 A1=FE_OFN41_n963 B0=n1028 B1=n2063 Y=n1573
XU1357 AO22X1TR $PINS A0=n933 A1=FE_OFN41_n963 B0=n1030 B1=n2064 Y=n1574
XU1358 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN41_n963 B0=n998 B1=n2066
+ Y=n1575
XU1359 AO22X1TR $PINS A0=FE_PSN238_n937 A1=FE_OFN87_n963 B0=n980 B1=n2067
+ Y=n1576
XU1360 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN87_n963 B0=n984 B1=n2068
+ Y=n1577
XU1361 AO22X1TR $PINS A0=FE_OFN134_n943 A1=FE_OFN87_n963 B0=n982 B1=n2069
+ Y=n1578
XU1362 AO22X1TR $PINS A0=FE_OFN68_n947 A1=FE_OFN88_n963 B0=n996 B1=n2071
+ Y=n1579
XU1363 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__2_ B=FE_OFN8_reset Y=n967
XU1365 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN43_n967 B0=n1015 B1=n2072
+ Y=n1580
XU1366 AO22X1TR $PINS A0=n882 A1=FE_OFN43_n967 B0=n1017 B1=n2073 Y=n1581
XU1367 AO22X1TR $PINS A0=n883 A1=n967 B0=n1025 B1=n2074 Y=n1582
XU1368 AO22X1TR $PINS A0=n884 A1=n967 B0=n1019 B1=n2075 Y=n1583
XU1369 AO22X1TR $PINS A0=n1032 A1=FE_OFN104_n967 B0=FE_OFN57_n886 B1=n2076
+ Y=n1584
XU1370 AO22X1TR $PINS A0=FE_OFN136_n887 A1=FE_OFN104_n967 B0=n1034 B1=n2077
+ Y=n1585
XU1371 AO22X1TR $PINS A0=n888 A1=FE_OFN104_n967 B0=n10 B1=n2078 Y=n1586
XU1372 AO22X1TR $PINS A0=n889 A1=FE_OFN104_n967 B0=n1037 B1=n2079 Y=n1587
XU1373 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN104_n967 B0=n1039 B1=n2080
+ Y=n1588
XU1374 AO22X1TR $PINS A0=FE_OFN75_n891 A1=FE_OFN104_n967 B0=n1041 B1=n2081
+ Y=n1589
XU1375 AO22X1TR $PINS A0=n896 A1=n967 B0=n1043 B1=n2082 Y=n1590
XU1376 AO22X2TR $PINS A0=FE_PSN237_n900 A1=n967 B0=n1021 B1=n2083 Y=n1591
XU1378 AO22X1TR $PINS A0=n903 A1=FE_OFN104_n967 B0=n978 B1=n2084 Y=n1592
XU1379 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN104_n967 B0=n1045 B1=n2085
+ Y=n1593
XU1380 AO22X1TR $PINS A0=n906 A1=n967 B0=n1023 B1=n2087 Y=n1594
XU1381 AO22X1TR $PINS A0=n908 A1=FE_OFN104_n967 B0=n1047 B1=n2089 Y=n1595
XU1382 AO22X1TR $PINS A0=FE_OFN109_n909 A1=FE_OFN43_n967 B0=n986 B1=n2090
+ Y=n1596
XU1383 AO22X1TR $PINS A0=n911 A1=FE_OFN43_n967 B0=n990 B1=n2092 Y=n1598
XU1384 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN104_n967 B0=n992 B1=n2093
+ Y=n1599
XU1385 AO22X1TR $PINS A0=FE_OFN101_n913 A1=FE_OFN43_n967 B0=n994 B1=n2094
+ Y=n1600
XU1386 AO22X1TR $PINS A0=n916 A1=FE_OFN43_n967 B0=FE_OFN63_n916 B1=n2095
+ Y=n1601
XU1387 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN43_n967 B0=n1000 B1=n2096
+ Y=n1602
XU1388 AO22X1TR $PINS A0=n918 A1=n967 B0=FE_OFN70_n918 B1=n2097 Y=n1603
XU1390 AO22X1TR $PINS A0=FE_OFN123_n921 A1=n967 B0=FE_OFN81_n921 B1=n2098
+ Y=n1604
XU1391 AO22X1TR $PINS A0=n925 A1=n967 B0=n1009 B1=n2100 Y=n1606
XU1392 AO22X1TR $PINS A0=n927 A1=FE_OFN43_n967 B0=n1011 B1=n2101 Y=n1607
XU1393 AO22X1TR $PINS A0=n928 A1=FE_OFN43_n967 B0=n1013 B1=n2102 Y=n1608
XU1394 AO22X1TR $PINS A0=n930 A1=n967 B0=n1028 B1=n2103 Y=n1609
XU1395 AO22X1TR $PINS A0=n933 A1=n967 B0=n1030 B1=n2104 Y=n1610
XU1396 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN43_n967 B0=n998 B1=n2106
+ Y=n1611
XU1397 AO22X1TR $PINS A0=n937 A1=FE_OFN43_n967 B0=n980 B1=n2107 Y=n1612
XU1398 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN43_n967 B0=n984 B1=n2108
+ Y=n1613
XU1399 AO22X1TR $PINS A0=FE_OFN133_n943 A1=FE_OFN43_n967 B0=n982 B1=n2109
+ Y=n1614
XU1400 AO22X1TR $PINS A0=FE_OFN68_n947 A1=FE_OFN104_n967 B0=n996 B1=n2111
+ Y=n1615
XU1401 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__1_ B=FE_OFN8_reset Y=n971
XU1403 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN46_n971 B0=n1015 B1=n2112
+ Y=n1616
XU1404 AO22X1TR $PINS A0=n882 A1=FE_OFN46_n971 B0=n1017 B1=n2113 Y=n1617
XU1405 AO22X1TR $PINS A0=n883 A1=FE_OFN46_n971 B0=n1025 B1=n2114 Y=n1618
XU1406 AO22X1TR $PINS A0=n884 A1=FE_OFN46_n971 B0=n1019 B1=n2115 Y=n1619
XU1407 AO22X1TR $PINS A0=n1032 A1=FE_OFN103_n971 B0=FE_OFN57_n886 B1=n2116
+ Y=n1620
XU1408 AO22X1TR $PINS A0=FE_OFN140_n887 A1=FE_OFN103_n971 B0=n1034 B1=n2117
+ Y=n1621
XU1409 AO22X1TR $PINS A0=n888 A1=FE_OFN103_n971 B0=n10 B1=n2118 Y=n1622
XU1410 AO22X1TR $PINS A0=n889 A1=FE_OFN103_n971 B0=n1037 B1=n2119 Y=n1623
XU1411 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN103_n971 B0=n1039 B1=n2120
+ Y=n1624
XU1412 AO22X1TR $PINS A0=FE_OFN78_n891 A1=FE_OFN103_n971 B0=n1041 B1=n2121
+ Y=n1625
XU1413 AO22X1TR $PINS A0=n896 A1=FE_OFN46_n971 B0=n1043 B1=n2122 Y=n1626
XU1414 AO22X1TR $PINS A0=n900 A1=FE_OFN46_n971 B0=n1021 B1=n2123 Y=n1627
XU1416 AO22X1TR $PINS A0=n903 A1=FE_OFN103_n971 B0=n978 B1=n2124 Y=n1628
XU1417 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN103_n971 B0=n1045 B1=n2125
+ Y=n1629
XU1418 AO22X1TR $PINS A0=n906 A1=n971 B0=n1023 B1=n2127 Y=n1630
XU1419 AO22X1TR $PINS A0=n908 A1=FE_OFN103_n971 B0=n1047 B1=n2129 Y=n1631
XU1420 AO22X1TR $PINS A0=FE_OFN111_n909 A1=FE_OFN103_n971 B0=n986 B1=n2130
+ Y=n1632
XU1421 AO22X1TR $PINS A0=n911 A1=FE_OFN46_n971 B0=n990 B1=n2132 Y=n1634
XU1422 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN103_n971 B0=n992 B1=n2133
+ Y=n1635
XU1423 AO22X1TR $PINS A0=FE_OFN100_n913 A1=FE_OFN103_n971 B0=n994 B1=n2134
+ Y=n1636
XU1424 AO22X1TR $PINS A0=n916 A1=n971 B0=FE_OFN63_n916 B1=n2135 Y=n1637
XU1425 AO22X1TR $PINS A0=FE_OFN121_n917 A1=n971 B0=n1000 B1=n2136 Y=n1638
XU1426 AO22X1TR $PINS A0=n918 A1=FE_OFN46_n971 B0=n1003 B1=n2137 Y=n1639
XU1428 AO22X1TR $PINS A0=FE_OFN126_n921 A1=FE_OFN46_n971 B0=FE_OFN81_n921
+ B1=n2138 Y=n1640
XU1429 AO22X1TR $PINS A0=FE_PSN236_n925 A1=FE_OFN46_n971 B0=n1009 B1=n2140
+ Y=n1642
XU1430 AO22X1TR $PINS A0=n927 A1=n971 B0=n1011 B1=n2141 Y=n1643
XU1431 AO22X1TR $PINS A0=n928 A1=n971 B0=n1013 B1=n2142 Y=n1644
XU1432 AO22X1TR $PINS A0=n930 A1=n971 B0=n1028 B1=n2143 Y=n1645
XU1433 AO22X1TR $PINS A0=n933 A1=n971 B0=n1030 B1=n2144 Y=n1646
XU1434 AO22X1TR $PINS A0=FE_OFN59_n935 A1=n971 B0=n998 B1=n2146 Y=n1647
XU1435 AO22X1TR $PINS A0=n937 A1=FE_OFN46_n971 B0=n980 B1=n2147 Y=n1648
XU1436 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN46_n971 B0=n984 B1=n2148
+ Y=n1649
XU1437 AO22X1TR $PINS A0=FE_OFN131_n943 A1=FE_OFN46_n971 B0=n982 B1=n2149
+ Y=n1650
XU1438 AO22X1TR $PINS A0=FE_OFN65_n947 A1=FE_OFN103_n971 B0=n996 B1=n2151
+ Y=n1651
XU1439 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__0_ B=FE_OFN8_reset Y=n975
XU1441 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN83_n975 B0=n1015 B1=n2152
+ Y=n1652
XU1442 AO22X1TR $PINS A0=n882 A1=FE_OFN83_n975 B0=n1017 B1=n2153 Y=n1653
XU1443 AO22X1TR $PINS A0=n883 A1=FE_OFN48_n975 B0=n1025 B1=n2154 Y=n1654
XU1444 AO22X1TR $PINS A0=n884 A1=FE_OFN48_n975 B0=n1019 B1=n2155 Y=n1655
XU1445 AO22X1TR $PINS A0=n1032 A1=FE_OFN84_n975 B0=FE_OFN57_n886 B1=n2156
+ Y=n1656
XU1446 AO22X1TR $PINS A0=FE_OFN140_n887 A1=FE_OFN84_n975 B0=n1034 B1=n2157
+ Y=n1657
XU1447 AO22X1TR $PINS A0=n888 A1=FE_OFN84_n975 B0=n10 B1=n2158 Y=n1658
XU1448 AO22X1TR $PINS A0=n889 A1=FE_OFN84_n975 B0=n1037 B1=n2159 Y=n1659
XU1449 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN84_n975 B0=n1039 B1=n2160
+ Y=n1660
XU1450 AO22X1TR $PINS A0=FE_OFN78_n891 A1=FE_OFN84_n975 B0=n1041 B1=n2161
+ Y=n1661
XU1451 AO22X1TR $PINS A0=n896 A1=FE_OFN48_n975 B0=n1043 B1=n2162 Y=n1662
XU1452 AO22X1TR $PINS A0=n900 A1=FE_OFN48_n975 B0=n1021 B1=n2163 Y=n1663
XU1454 AO22X1TR $PINS A0=n903 A1=FE_OFN84_n975 B0=n978 B1=n2164 Y=n1664
XU1455 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN84_n975 B0=n1045 B1=n2165
+ Y=n1665
XU1456 AO22X1TR $PINS A0=n906 A1=FE_OFN48_n975 B0=n1023 B1=n2167 Y=n1666
XU1457 AO22X1TR $PINS A0=n908 A1=FE_OFN84_n975 B0=n1047 B1=n2169 Y=n1667
XU1458 AO22X1TR $PINS A0=FE_OFN107_n909 A1=FE_OFN84_n975 B0=n986 B1=n2170
+ Y=n1668
XU1459 AO22X1TR $PINS A0=n911 A1=FE_OFN83_n975 B0=n990 B1=n2172 Y=n1670
XU1460 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN83_n975 B0=n992 B1=n2173
+ Y=n1671
XU1461 AO22X1TR $PINS A0=FE_OFN98_n913 A1=FE_OFN83_n975 B0=n994 B1=n2174
+ Y=n1672
XU1462 AO22X1TR $PINS A0=n916 A1=FE_OFN48_n975 B0=FE_OFN63_n916 B1=n2175
+ Y=n1673
XU1463 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN48_n975 B0=n1000 B1=n2176
+ Y=n1674
XU1464 AO22X1TR $PINS A0=n918 A1=FE_OFN83_n975 B0=n1003 B1=n2177 Y=n1675
XU1466 AO22X1TR $PINS A0=FE_OFN122_n921 A1=FE_OFN83_n975 B0=FE_OFN81_n921
+ B1=n2178 Y=n1676
XU1467 AO22X1TR $PINS A0=n925 A1=FE_OFN48_n975 B0=n1009 B1=n2180 Y=n1678
XU1468 AO22X1TR $PINS A0=n927 A1=FE_OFN48_n975 B0=n1011 B1=n2181 Y=n1679
XU1469 AO22X1TR $PINS A0=n928 A1=FE_OFN48_n975 B0=n1013 B1=n2182 Y=n1680
XU1470 AO22X1TR $PINS A0=n930 A1=FE_OFN48_n975 B0=n1028 B1=n2183 Y=n1681
XU1471 AO22X1TR $PINS A0=n933 A1=FE_OFN48_n975 B0=n1030 B1=n2184 Y=n1682
XU1472 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_OFN48_n975 B0=n998 B1=n2186
+ Y=n1683
XU1473 AO22X1TR $PINS A0=n937 A1=FE_OFN83_n975 B0=n980 B1=n2187 Y=n1684
XU1474 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN83_n975 B0=n984 B1=n2188
+ Y=n1685
XU1475 AO22X1TR $PINS A0=FE_OFN129_n943 A1=FE_OFN83_n975 B0=n982 B1=n2189
+ Y=n1686
XU1476 AO22X1TR $PINS A0=FE_OFN64_n947 A1=FE_OFN83_n975 B0=n996 B1=n2191
+ Y=n1687
XU1477 AO22X1TR $PINS A0=n903 A1=FE_OFN27_FE_DBTN1_reset B0=n978 B1=n2192
+ Y=n1688
XU1478 AO22X1TR $PINS A0=n937 A1=FE_OFN116_n B0=n980 B1=n2193 Y=n1689
XU1479 AO22X1TR $PINS A0=FE_OFN130_n943 A1=FE_OFN27_FE_DBTN1_reset B0=n982
+ B1=n2194 Y=n1690
XU1480 AO22X1TR $PINS A0=FE_OFN127_n939 A1=FE_OFN116_n B0=n984 B1=n2196 Y=n1691
XU1481 AO22X1TR $PINS A0=FE_OFN108_n909 A1=FE_OFN27_FE_DBTN1_reset B0=n986
+ B1=n2197 Y=n1692
XU1482 AO22X1TR $PINS A0=n911 A1=FE_OFN116_n B0=n990 B1=n2199 Y=n1694
XU1483 AO22X1TR $PINS A0=FE_OFN61_n912 A1=FE_OFN32_FE_DBTN1_reset B0=n992
+ B1=n2200 Y=n1695
XU1484 AO22X1TR $PINS A0=FE_OFN99_n913 A1=FE_OFN32_FE_DBTN1_reset B0=n994
+ B1=n2201 Y=n1696
XU1485 AO22X1TR $PINS A0=FE_OFN66_n947 A1=FE_OFN32_FE_DBTN1_reset B0=n996
+ B1=n2202 Y=n1697
XU1486 AO22X1TR $PINS A0=FE_OFN59_n935 A1=FE_DBTN1_reset B0=n998 B1=n2203
+ Y=n1698
XU1487 AO22X1TR $PINS A0=FE_OFN121_n917 A1=FE_OFN115_n B0=n1000 B1=n2204
+ Y=n1699
XU1488 AO22X1TR $PINS A0=n918 A1=FE_OFN27_FE_DBTN1_reset B0=n1003 B1=n2205
+ Y=n1700
XU1489 AO22X1TR $PINS A0=FE_OFN126_n921 A1=FE_OFN116_n B0=FE_OFN81_n921
+ B1=n2206 Y=n1701
XU1490 AO22X1TR $PINS A0=FE_PSN236_n925 A1=FE_OFN29_FE_DBTN1_reset B0=n1009
+ B1=n2208 Y=n1703
XU1491 AO22X1TR $PINS A0=n927 A1=FE_OFN32_FE_DBTN1_reset B0=n1011 B1=n2209
+ Y=n1704
XU1492 AO22X1TR $PINS A0=n928 A1=FE_OFN32_FE_DBTN1_reset B0=n1013 B1=n2210
+ Y=n1705
XU1493 AO22X1TR $PINS A0=FE_PSN235_n880 A1=FE_OFN115_n B0=n1015 B1=n2211
+ Y=n1706
XU1494 AO22X1TR $PINS A0=n882 A1=FE_OFN31_FE_DBTN1_reset B0=n1017 B1=n2212
+ Y=n1707
XU1495 AO22X1TR $PINS A0=n884 A1=FE_OFN31_FE_DBTN1_reset B0=n1019 B1=n2213
+ Y=n1708
XU1496 AO22X1TR $PINS A0=n900 A1=FE_OFN31_FE_DBTN1_reset B0=n1021 B1=n2214
+ Y=n1709
XU1497 AO22X1TR $PINS A0=n906 A1=FE_DBTN1_reset B0=n1023 B1=n2215 Y=n1710
XU1498 AO22X1TR $PINS A0=n883 A1=FE_OFN31_FE_DBTN1_reset B0=n1025 B1=n2216
+ Y=n1711
XU1499 AO22X1TR $PINS A0=n930 A1=FE_OFN31_FE_DBTN1_reset B0=n1028 B1=n2217
+ Y=n1712
XU1500 AO22X1TR $PINS A0=n933 A1=FE_OFN31_FE_DBTN1_reset B0=n1030 B1=n2218
+ Y=n1713
XU1501 AO22X1TR $PINS A0=n1032 A1=FE_OFN27_FE_DBTN1_reset B0=FE_OFN57_n886
+ B1=n2219 Y=n1714
XU1502 AO22X1TR $PINS A0=FE_OFN135_n887 A1=FE_OFN27_FE_DBTN1_reset B0=n1034
+ B1=n2220 Y=n1715
XU1503 AO22X1TR $PINS A0=n888 A1=FE_OFN116_n B0=n10 B1=n2221 Y=n1716
XU1504 AO22X1TR $PINS A0=n889 A1=FE_OFN116_n B0=n1037 B1=n2222 Y=n1717
XU1505 AO22X1TR $PINS A0=FE_OFN50_n890 A1=FE_OFN116_n B0=n1039 B1=n2223 Y=n1718
XU1506 AO22X1TR $PINS A0=FE_OFN74_n891 A1=FE_OFN27_FE_DBTN1_reset B0=n1041
+ B1=n2224 Y=n1719
XU1507 AO22X1TR $PINS A0=n896 A1=FE_OFN31_FE_DBTN1_reset B0=n1043 B1=n2225
+ Y=n1720
XU1508 AO22X1TR $PINS A0=FE_OFN60_n904 A1=FE_OFN27_FE_DBTN1_reset B0=n1045
+ B1=n2226 Y=n1721
XU1509 AO22X1TR $PINS A0=n908 A1=FE_DBTN1_reset B0=n1047 B1=n2227 Y=n1722
XU1510 AO22X1TR $PINS A0=n916 A1=FE_OFN115_n B0=FE_OFN63_n916 B1=n2228 Y=n1723
XU1511 NAND2X1TR $PINS A=n1052 B=n1057 Y=n1053
XU1512 XNOR2X1TR $PINS A=n1056 B=n1053 Y=n1054
XU1513 NAND2X1TR $PINS A=pe_out_pk_data__2_ B=n1072 Y=n1055
XU1515 OAI21X1TR $PINS A0=n1059 A1=n1058 B0=n1057 Y=n1064
XU1516 NAND2X1TR $PINS A=n1062 B=n1061 Y=n1063
XU1517 XNOR2X1TR $PINS A=n1064 B=n1063 Y=n1065
XU1518 AND2X2TR $PINS A=n1065 B=FE_OFN29_FE_DBTN1_reset Y=pe_out_pk_data__3_
XU1519 NAND2X1TR $PINS A=pe_out_pk_data__3_ B=n1072 Y=n1066
XU1520 OAI2BB2XLTR $PINS A0N=n616 A1N=n2230 B0=n1066 B1=n616 Y=n1725
XU1521 NAND2X1TR $PINS A=n1068 B=n1067 Y=n1069
XU1522 XNOR2X1TR $PINS A=n1070 B=n1069 Y=n1071
XU1523 NAND2X1TR $PINS A=pe_out_pk_data__5_ B=n1072 Y=n1073
XU1524 OAI2BB2XLTR $PINS A0N=n616 A1N=n2231 B0=n1073 B1=n616 Y=n1726
XU1525 NOR2X1TR $PINS A=FE_OFN8_reset B=pe_in_pk_rdb_addr__3_ Y=n1107
XU1527 NOR3X1TR $PINS A=FE_OFN89_pe_in_pk_rdb_addr__2 B=pe_in_pk_rdb_addr__1_
+ C=n1079 Y=n1097
XU1529 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2223 B0=FE_OFN55_n1097 B1=n2224
+ Y=n1084
XU1530 CLKAND2X3TR $PINS A=n1078 B=n1074 Y=n1098
XU1532 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2222 B0=FE_OFN21_n1099 B1=n2221
+ Y=n1083
XU1533 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2219 B0=FE_OFN51_n1076 B1=n2220
+ Y=n1082
XU1534 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2226 B0=FE_OFN80_n1080 B1=n2192
+ Y=n1081
XU1535 NAND4X1TR $PINS A=n1084 B=n1083 C=n1082 D=n1081 Y=n1085
XU1536 AND2X2TR $PINS A=n1107 B=n1085 Y=n2265
XU1537 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2217 B0=FE_OFN54_n1097 B1=n2218
+ Y=n1089
XU1538 AOI22X1TR $PINS A0=n1098 A1=n2216 B0=n1099 B1=n2213 Y=n1088
XU1539 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2211 B0=n1076 B1=n2212 Y=n1087
XU1540 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2214 B0=FE_OFN13_n1080 B1=n2225
+ Y=n1086
XU1541 NAND4X1TR $PINS A=n1089 B=n1088 C=n1087 D=n1086 Y=n1090
XU1542 AND2X2TR $PINS A=n1107 B=n1090 Y=n2255
XU1544 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2209 B0=FE_OFN18_n1097 B1=n2210
+ Y=n1094
XU1547 AOI22X1TR $PINS A0=FE_OFN95_n1098 A1=n2208 B0=n1099 B1=n2207 Y=n1093
XU1548 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2205 B0=FE_OFN11_n1076 B1=n2206
+ Y=n1092
XU1549 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2228 B0=FE_OFN12_n1080 B1=n2204
+ Y=n1091
XU1550 NAND4X1TR $PINS A=n1094 B=n1093 C=n1092 D=n1091 Y=n1095
XU1551 AND2X2TR $PINS A=n1107 B=n1095 Y=n2245
XU1553 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2200 B0=FE_OFN55_n1097 B1=n2201
+ Y=n1105
XU1556 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2199 B0=FE_OFN21_n1099 B1=n2198
+ Y=n1104
XU1557 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2194 B0=FE_OFN51_n1076 B1=n2197
+ Y=n1103
XU1558 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2193 B0=FE_OFN80_n1080 B1=n2196
+ Y=n1102
XU1559 NAND4X1TR $PINS A=n1105 B=n1104 C=n1103 D=n1102 Y=n1106
XU1560 AND2X2TR $PINS A=n1107 B=n1106 Y=n2235
XU1561 NAND2X1TR $PINS A=n1109 B=n1108 Y=PE_top0_DP_OP_17J1_122_4844_n25
XU1562 NAND2X1TR $PINS A=n1111 B=n1110 Y=PE_top0_DP_OP_17J1_122_4844_n28
XU1563 OAI21X1TR $PINS A0=n1116 A1=n1115 B0=n1114
+ Y=PE_top0_DP_OP_17J1_122_4844_n37
XU1564 NAND2X1TR $PINS A=n1118 B=n1117 Y=n1120
XU1565 XNOR2X1TR $PINS A=n1120 B=n1119 Y=PE_top0_adder0_out_int2<0>
XU1566 NAND2X1TR $PINS A=n1122 B=n1121 Y=n1124
XU1567 XNOR2X1TR $PINS A=n1124 B=n1123 Y=n1125
XU1568 NAND2X1TR $PINS A=n1127 B=n1126 Y=n1129
XU1569 AND2X2TR $PINS A=n1130 B=FE_DBTN1_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out1_0_
XU1570 NAND2X1TR $PINS A=n1132 B=n1131 Y=n1134
XU1571 XNOR2X1TR $PINS A=n1134 B=n1133 Y=n1135
XU1572 NAND2X1TR $PINS A=n1137 B=n1136 Y=n1139
XU1573 XNOR2X1TR $PINS A=n1139 B=n1138 Y=n1140
XU1574 AND2X2TR $PINS A=n1140 B=FE_OFN32_FE_DBTN1_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out1_0_
XU1575 NOR2BX1TR $PINS AN=n1776 B=FE_OFN117_n Y=PE_top0_OUT_ADD<0>
XU1576 NAND2X1TR $PINS A=n1141 B=n1774 Y=n1142
XU1577 XOR2X1TR $PINS A=n1142 B=n1144 Y=n1143
XU1578 AND2X1TR $PINS A=n1143 B=FE_OFN29_FE_DBTN1_reset Y=PE_top0_OUT_ADD<2>
XU1579 OAI21X1TR $PINS A0=n1144 A1=n1773 B0=n1774 Y=n1147
XU1580 NAND2X1TR $PINS A=n1145 B=n1772 Y=n1146
XU1581 XNOR2X1TR $PINS A=n1147 B=n1146 Y=n1148
XU1582 AND2X1TR $PINS A=n1148 B=FE_OFN118_n Y=PE_top0_OUT_ADD<3>
XU1583 NAND2X1TR $PINS A=n1149 B=n1770 Y=n1150
XU1584 XOR2X1TR $PINS A=n1160 B=n1150 Y=n1151
XU1585 NOR2BX1TR $PINS AN=n1151 B=FE_OFN117_n Y=PE_top0_OUT_ADD<4>
XU1586 OAI21X1TR $PINS A0=n1160 A1=n1769 B0=n1770 Y=n1154
XU1587 NAND2X1TR $PINS A=n1152 B=n1768 Y=n1153
XU1588 XNOR2X1TR $PINS A=n1154 B=n1153 Y=n1155
XU1589 NOR2BX1TR $PINS AN=n1155 B=FE_OFN113_reset Y=PE_top0_OUT_ADD<5>
XU1590 OAI21X1TR $PINS A0=n1160 A1=n1159 B0=n1158 Y=n1162
XU1591 NAND2X1TR $PINS A=n1871 B=n1766 Y=n1161
XU1592 XNOR2X1TR $PINS A=n1162 B=n1161 Y=n1163
XU1593 NOR2BX1TR $PINS AN=n1163 B=FE_OFN117_n Y=PE_top0_OUT_ADD<6>
XU1594 NOR2BX1TR $PINS AN=n1834 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<7>
XU1596 NOR2BX1TR $PINS AN=n1833 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<6>
XU1597 NOR2BX1TR $PINS AN=n1832 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<5>
XU1598 NOR2BX1TR $PINS AN=n1831 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<4>
XU1599 NOR2BX1TR $PINS AN=n1830 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<3>
XU1600 NOR2BX1TR $PINS AN=n1829 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<2>
XU1601 NOR2BX1TR $PINS AN=n1828 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<1>
XU1602 NOR2BX1TR $PINS AN=n1827 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<0>
XU1603 NOR2BX1TR $PINS AN=n1858 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<7>
XU1604 NOR2BX1TR $PINS AN=n1857 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<6>
XU1605 NOR2BX1TR $PINS AN=n1856 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<5>
XU1606 NOR2BX1TR $PINS AN=n1855 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<4>
XU1607 NOR2BX1TR $PINS AN=n1854 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<3>
XU1608 NOR2BX1TR $PINS AN=n1853 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<2>
XU1609 NOR2BX1TR $PINS AN=n1852 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<1>
XU1610 NOR2BX1TR $PINS AN=n1851 B=FE_OFN7_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<0>
XU1611 NOR2BX1TR $PINS AN=n1850 B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<7>
XU1612 NOR2BX1TR $PINS AN=n1849 B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<6>
XU1613 NOR2BX1TR $PINS AN=n1848 B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<5>
XU1614 NOR2BX1TR $PINS AN=n1847 B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<4>
XU1615 NOR2BX1TR $PINS AN=n1846 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<3>
XU1616 NOR2BX1TR $PINS AN=n1845 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<2>
XU1617 NOR2BX1TR $PINS AN=n1844 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<1>
XU1618 NOR2BX1TR $PINS AN=n1843 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<0>
XU1619 NOR2BX1TR $PINS AN=n1842 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<7>
XU1620 NOR2BX1TR $PINS AN=n1841 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<6>
XU1621 NOR2BX1TR $PINS AN=n1840 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<5>
XU1622 NOR2BX1TR $PINS AN=n1839 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<4>
XU1623 NOR2BX1TR $PINS AN=n1838 B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<3>
XU1624 NOR2BX1TR $PINS AN=n1837 B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<2>
XU1625 NOR2BX1TR $PINS AN=n1836 B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<1>
XU1626 NOR2BX1TR $PINS AN=n1835 B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<0>
XU1627 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1893 B0=FE_OFN55_n1097 B1=n1894
+ Y=n1171
XU1628 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n1892 B0=FE_OFN21_n1099 B1=n1891
+ Y=n1170
XU1629 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1909 B0=FE_OFN51_n1076 B1=n1890
+ Y=n1169
XU1630 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1907 B0=FE_OFN80_n1080 B1=n1908
+ Y=n1168
XU1631 NAND4X1TR $PINS A=n1171 B=n1170 C=n1169 D=n1168 Y=n2236
XU1632 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1933 B0=FE_OFN55_n1097 B1=n1934
+ Y=n1175
XU1633 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n1932 B0=FE_OFN21_n1099 B1=n1931
+ Y=n1174
XU1634 AOI22X1TR $PINS A0=FE_OFN128_n1100 A1=n1949 B0=FE_OFN51_n1076 B1=n1930
+ Y=n1173
XU1635 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1947 B0=FE_OFN80_n1080 B1=n1948
+ Y=n1172
XU1636 NAND4X1TR $PINS A=n1175 B=n1174 C=n1173 D=n1172 Y=n2238
XU1637 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1973 B0=FE_OFN55_n1097 B1=n1974
+ Y=n1179
XU1638 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n1972 B0=FE_OFN21_n1099 B1=n1971
+ Y=n1178
XU1639 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1989 B0=FE_OFN51_n1076 B1=n1970
+ Y=n1177
XU1640 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1987 B0=FE_OFN80_n1080 B1=n1988
+ Y=n1176
XU1641 NAND4X1TR $PINS A=n1179 B=n1178 C=n1177 D=n1176 Y=n2239
XU1642 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2013 B0=FE_OFN18_n1097 B1=n2014
+ Y=n1183
XU1643 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2012 B0=FE_OFN21_n1099 B1=n2011
+ Y=n1182
XU1644 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2029 B0=FE_OFN51_n1076 B1=n2010
+ Y=n1181
XU1645 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2027 B0=FE_OFN12_n1080 B1=n2028
+ Y=n1180
XU1646 NAND4X1TR $PINS A=n1183 B=n1182 C=n1181 D=n1180 Y=n2240
XU1647 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2053 B0=FE_OFN55_n1097 B1=n2054
+ Y=n1187
XU1648 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2052 B0=FE_OFN21_n1099 B1=n2051
+ Y=n1186
XU1649 AOI22X1TR $PINS A0=FE_OFN128_n1100 A1=n2069 B0=FE_OFN11_n1076 B1=n2050
+ Y=n1185
XU1650 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2067 B0=FE_OFN80_n1080 B1=n2068
+ Y=n1184
XU1651 NAND4X1TR $PINS A=n1187 B=n1186 C=n1185 D=n1184 Y=n2241
XU1652 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2093 B0=FE_OFN55_n1097 B1=n2094
+ Y=n1191
XU1653 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2092 B0=FE_OFN21_n1099 B1=n2091
+ Y=n1190
XU1654 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2109 B0=FE_OFN51_n1076 B1=n2090
+ Y=n1189
XU1655 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2107 B0=FE_OFN80_n1080 B1=n2108
+ Y=n1188
XU1656 NAND4X1TR $PINS A=n1191 B=n1190 C=n1189 D=n1188 Y=n2242
XU1657 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2133 B0=FE_OFN55_n1097 B1=n2134
+ Y=n1195
XU1658 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2132 B0=FE_OFN21_n1099 B1=n2131
+ Y=n1194
XU1659 AOI22X1TR $PINS A0=FE_OFN128_n1100 A1=n2149 B0=FE_OFN11_n1076 B1=n2130
+ Y=n1193
XU1660 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2147 B0=FE_OFN80_n1080 B1=n2148
+ Y=n1192
XU1661 NAND4X1TR $PINS A=n1195 B=n1194 C=n1193 D=n1192 Y=n2243
XU1662 NOR2BX1TR $PINS AN=n2202 B=n1305 Y=n2237
XU1663 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2173 B0=FE_OFN18_n1097 B1=n2174
+ Y=n1200
XU1664 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2172 B0=FE_OFN21_n1099 B1=n2171
+ Y=n1199
XU1665 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2189 B0=FE_OFN51_n1076 B1=n2170
+ Y=n1198
XU1666 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2187 B0=FE_OFN12_n1080 B1=n2188
+ Y=n1197
XU1667 NAND4X1TR $PINS A=n1200 B=n1199 C=n1198 D=n1197 Y=n2244
XU1668 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n1901 B0=FE_OFN18_n1097 B1=n1902
+ Y=n1204
XU1669 AOI22X1TR $PINS A0=n1098 A1=n1900 B0=n1099 B1=n1899 Y=n1203
XU1670 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n1897 B0=FE_OFN11_n1076 B1=n1898
+ Y=n1202
XU1671 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n1895 B0=FE_OFN12_n1080 B1=n1896
+ Y=n1201
XU1672 NAND4X1TR $PINS A=n1204 B=n1203 C=n1202 D=n1201 Y=n2246
XU1673 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n1941 B0=FE_OFN18_n1097 B1=n1942
+ Y=n1208
XU1674 AOI22X1TR $PINS A0=FE_OFN95_n1098 A1=n1940 B0=n1099 B1=n1939 Y=n1207
XU1675 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n1937 B0=FE_OFN11_n1076 B1=n1938
+ Y=n1206
XU1676 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n1935 B0=FE_OFN12_n1080 B1=n1936
+ Y=n1205
XU1677 NAND4X1TR $PINS A=n1208 B=n1207 C=n1206 D=n1205 Y=n2248
XU1678 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n1981 B0=FE_OFN18_n1097 B1=n1982
+ Y=n1218
XU1679 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n1980 B0=FE_OFN21_n1099 B1=n1979
+ Y=n1217
XU1680 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n1977 B0=FE_OFN11_n1076 B1=n1978
+ Y=n1216
XU1681 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n1975 B0=FE_OFN12_n1080 B1=n1976
+ Y=n1215
XU1682 NAND4X1TR $PINS A=n1218 B=n1217 C=n1216 D=n1215 Y=n2249
XU1683 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2021 B0=FE_OFN18_n1097 B1=n2022
+ Y=n1222
XU1684 AOI22X1TR $PINS A0=FE_OFN20_n1098 A1=n2020 B0=FE_OFN21_n1099 B1=n2019
+ Y=n1221
XU1685 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2017 B0=FE_OFN11_n1076 B1=n2018
+ Y=n1220
XU1686 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2015 B0=FE_OFN12_n1080 B1=n2016
+ Y=n1219
XU1687 NAND4X1TR $PINS A=n1222 B=n1221 C=n1220 D=n1219 Y=n2250
XU1688 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2061 B0=FE_OFN18_n1097 B1=n2062
+ Y=n1226
XU1689 AOI22X1TR $PINS A0=FE_OFN95_n1098 A1=n2060 B0=n1099 B1=n2059 Y=n1225
XU1690 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2057 B0=FE_OFN11_n1076 B1=n2058
+ Y=n1224
XU1691 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2055 B0=FE_OFN12_n1080 B1=n2056
+ Y=n1223
XU1692 NAND4X1TR $PINS A=n1226 B=n1225 C=n1224 D=n1223 Y=n2251
XU1693 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2101 B0=FE_OFN18_n1097 B1=n2102
+ Y=n1230
XU1694 AOI22X1TR $PINS A0=FE_OFN95_n1098 A1=n2100 B0=n1099 B1=n2099 Y=n1229
XU1695 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2097 B0=FE_OFN11_n1076 B1=n2098
+ Y=n1228
XU1696 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2095 B0=FE_OFN12_n1080 B1=n2096
+ Y=n1227
XU1697 NAND4X1TR $PINS A=n1230 B=n1229 C=n1228 D=n1227 Y=n2252
XU1698 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2141 B0=FE_OFN18_n1097 B1=n2142
+ Y=n1234
XU1699 AOI22X1TR $PINS A0=n1098 A1=n2140 B0=FE_OFN21_n1099 B1=n2139 Y=n1233
XU1700 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2137 B0=FE_OFN11_n1076 B1=n2138
+ Y=n1232
XU1701 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2135 B0=FE_OFN12_n1080 B1=n2136
+ Y=n1231
XU1702 NAND4X1TR $PINS A=n1234 B=n1233 C=n1232 D=n1231 Y=n2253
XU1703 NOR2BX1TR $PINS AN=n2203 B=n1305 Y=n2247
XU1704 AOI22X1TR $PINS A0=FE_OFN14_n1096 A1=n2181 B0=FE_OFN18_n1097 B1=n2182
+ Y=n1238
XU1705 AOI22X1TR $PINS A0=n1098 A1=n2180 B0=n1099 B1=n2179 Y=n1237
XU1706 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2177 B0=FE_OFN11_n1076 B1=n2178
+ Y=n1236
XU1707 AOI22X1TR $PINS A0=FE_OFN52_n1101 A1=n2175 B0=FE_OFN12_n1080 B1=n2176
+ Y=n1235
XU1708 NAND4X1TR $PINS A=n1238 B=n1237 C=n1236 D=n1235 Y=n2254
XU1709 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n1903 B0=FE_OFN54_n1097 B1=n1904
+ Y=n1242
XU1710 AOI22X1TR $PINS A0=n1098 A1=n1874 B0=n1099 B1=n1875 Y=n1241
XU1711 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n1872 B0=n1076 B1=n1873 Y=n1240
XU1712 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n1883 B0=FE_OFN13_n1080 B1=n1882
+ Y=n1239
XU1713 NAND4X1TR $PINS A=n1242 B=n1241 C=n1240 D=n1239 Y=n2256
XU1714 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n1943 B0=FE_OFN54_n1097 B1=n1944
+ Y=n1246
XU1715 AOI22X1TR $PINS A0=n1098 A1=n1914 B0=n1099 B1=n1915 Y=n1245
XU1716 AOI22X1TR $PINS A0=n1100 A1=n1912 B0=n1076 B1=n1913 Y=n1244
XU1717 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n1923 B0=FE_OFN13_n1080 B1=n1922
+ Y=n1243
XU1718 NAND4X1TR $PINS A=n1246 B=n1245 C=n1244 D=n1243 Y=n2258
XU1719 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n1983 B0=FE_OFN54_n1097 B1=n1984
+ Y=n1250
XU1720 AOI22X1TR $PINS A0=n1098 A1=n1954 B0=n1099 B1=n1955 Y=n1249
XU1721 AOI22X1TR $PINS A0=n1100 A1=n1952 B0=n1076 B1=n1953 Y=n1248
XU1722 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n1963 B0=FE_OFN13_n1080 B1=n1962
+ Y=n1247
XU1723 NAND4X1TR $PINS A=n1250 B=n1249 C=n1248 D=n1247 Y=n2259
XU1724 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2023 B0=FE_OFN54_n1097 B1=n2024
+ Y=n1254
XU1725 AOI22X1TR $PINS A0=n1098 A1=n1994 B0=n1099 B1=n1995 Y=n1253
XU1726 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n1992 B0=FE_OFN11_n1076 B1=n1993
+ Y=n1252
XU1727 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2003 B0=FE_OFN13_n1080 B1=n2002
+ Y=n1251
XU1728 NAND4X1TR $PINS A=n1254 B=n1253 C=n1252 D=n1251 Y=n2260
XU1729 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2063 B0=FE_OFN54_n1097 B1=n2064
+ Y=n1258
XU1730 AOI22X1TR $PINS A0=n1098 A1=n2034 B0=n1099 B1=n2035 Y=n1257
XU1731 AOI22X1TR $PINS A0=n1100 A1=n2032 B0=n1076 B1=n2033 Y=n1256
XU1732 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2043 B0=FE_OFN13_n1080 B1=n2042
+ Y=n1255
XU1733 NAND4X1TR $PINS A=n1258 B=n1257 C=n1256 D=n1255 Y=n2261
XU1734 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2103 B0=FE_OFN54_n1097 B1=n2104
+ Y=n1268
XU1735 AOI22X1TR $PINS A0=n1098 A1=n2074 B0=n1099 B1=n2075 Y=n1267
XU1736 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2072 B0=FE_OFN11_n1076 B1=n2073
+ Y=n1266
XU1737 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2083 B0=FE_OFN13_n1080 B1=n2082
+ Y=n1265
XU1738 NAND4X1TR $PINS A=n1268 B=n1267 C=n1266 D=n1265 Y=n2262
XU1739 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2143 B0=FE_OFN54_n1097 B1=n2144
+ Y=n1272
XU1740 AOI22X1TR $PINS A0=n1098 A1=n2114 B0=n1099 B1=n2115 Y=n1271
XU1741 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2112 B0=FE_OFN11_n1076 B1=n2113
+ Y=n1270
XU1742 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2123 B0=FE_OFN13_n1080 B1=n2122
+ Y=n1269
XU1743 NAND4X1TR $PINS A=n1272 B=n1271 C=n1270 D=n1269 Y=n2263
XU1744 NOR2BX1TR $PINS AN=n2215 B=n1305 Y=n2257
XU1745 AOI22X1TR $PINS A0=FE_OFN16_n1096 A1=n2183 B0=FE_OFN54_n1097 B1=n2184
+ Y=n1276
XU1746 AOI22X1TR $PINS A0=n1098 A1=n2154 B0=n1099 B1=n2155 Y=n1275
XU1747 AOI22X1TR $PINS A0=FE_OFN23_n1100 A1=n2152 B0=FE_OFN11_n1076 B1=n2153
+ Y=n1274
XU1748 AOI22X1TR $PINS A0=FE_OFN26_n1101 A1=n2163 B0=FE_OFN13_n1080 B1=n2162
+ Y=n1273
XU1749 NAND4X1TR $PINS A=n1276 B=n1275 C=n1274 D=n1273 Y=n2264
XU1750 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1880 B0=FE_OFN55_n1097 B1=n1881
+ Y=n1280
XU1751 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n1879 B0=FE_OFN22_n1099 B1=n1878
+ Y=n1279
XU1752 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1876 B0=FE_OFN51_n1076 B1=n1877
+ Y=n1278
XU1753 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1885 B0=FE_OFN80_n1080 B1=n1884
+ Y=n1277
XU1754 NAND4X1TR $PINS A=n1280 B=n1279 C=n1278 D=n1277 Y=n2266
XU1755 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1920 B0=FE_OFN55_n1097 B1=n1921
+ Y=n1284
XU1756 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n1919 B0=FE_OFN22_n1099 B1=n1918
+ Y=n1283
XU1757 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1916 B0=FE_OFN51_n1076 B1=n1917
+ Y=n1282
XU1758 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1925 B0=FE_OFN80_n1080 B1=n1924
+ Y=n1281
XU1759 NAND4X1TR $PINS A=n1284 B=n1283 C=n1282 D=n1281 Y=n2268
XU1760 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n1960 B0=FE_OFN55_n1097 B1=n1961
+ Y=n1288
XU1761 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n1959 B0=FE_OFN22_n1099 B1=n1958
+ Y=n1287
XU1762 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1956 B0=FE_OFN51_n1076 B1=n1957
+ Y=n1286
XU1763 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n1965 B0=FE_OFN80_n1080 B1=n1964
+ Y=n1285
XU1764 NAND4X1TR $PINS A=n1288 B=n1287 C=n1286 D=n1285 Y=n2269
XU1765 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2000 B0=FE_OFN55_n1097 B1=n2001
+ Y=n1292
XU1766 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n1999 B0=FE_OFN22_n1099 B1=n1998
+ Y=n1291
XU1767 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n1996 B0=FE_OFN51_n1076 B1=n1997
+ Y=n1290
XU1768 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2005 B0=FE_OFN80_n1080 B1=n2004
+ Y=n1289
XU1769 NAND4X1TR $PINS A=n1292 B=n1291 C=n1290 D=n1289 Y=n2270
XU1770 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2040 B0=FE_OFN55_n1097 B1=n2041
+ Y=n1296
XU1771 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n2039 B0=FE_OFN22_n1099 B1=n2038
+ Y=n1295
XU1772 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2036 B0=FE_OFN51_n1076 B1=n2037
+ Y=n1294
XU1773 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2045 B0=FE_OFN80_n1080 B1=n2044
+ Y=n1293
XU1774 NAND4X1TR $PINS A=n1296 B=n1295 C=n1294 D=n1293 Y=n2271
XU1775 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2080 B0=FE_OFN55_n1097 B1=n2081
+ Y=n1300
XU1776 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n2079 B0=FE_OFN22_n1099 B1=n2078
+ Y=n1299
XU1777 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2076 B0=FE_OFN51_n1076 B1=n2077
+ Y=n1298
XU1778 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2085 B0=FE_OFN80_n1080 B1=n2084
+ Y=n1297
XU1779 NAND4X1TR $PINS A=n1300 B=n1299 C=n1298 D=n1297 Y=n2272
XU1780 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2120 B0=FE_OFN55_n1097 B1=n2121
+ Y=n1304
XU1781 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n2119 B0=FE_OFN22_n1099 B1=n2118
+ Y=n1303
XU1782 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2116 B0=FE_OFN51_n1076 B1=n2117
+ Y=n1302
XU1783 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2125 B0=FE_OFN80_n1080 B1=n2124
+ Y=n1301
XU1784 NAND4X1TR $PINS A=n1304 B=n1303 C=n1302 D=n1301 Y=n2273
XU1785 NOR2BX1TR $PINS AN=n2227 B=n1305 Y=n2267
XU1786 AOI22X1TR $PINS A0=FE_OFN79_n1096 A1=n2160 B0=FE_OFN55_n1097 B1=n2161
+ Y=n1315
XU1787 AOI22X1TR $PINS A0=FE_OFN96_n1098 A1=n2159 B0=FE_OFN22_n1099 B1=n2158
+ Y=n1314
XU1788 AOI22X1TR $PINS A0=FE_OFN105_n1100 A1=n2156 B0=FE_OFN51_n1076 B1=n2157
+ Y=n1313
XU1789 AOI22X1TR $PINS A0=FE_OFN53_n1101 A1=n2165 B0=FE_OFN80_n1080 B1=n2164
+ Y=n1312
XU1790 NAND4X1TR $PINS A=n1315 B=n1314 C=n1313 D=n1312 Y=n2274
XU1791 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__2_ B=FE_OFN112_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<2>
XU1792 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__1_ B=FE_OFN112_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<1>
XU1793 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__0_ B=FE_OFN112_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<0>
XU1794 NOR2BX1TR $PINS AN=n1808 B=FE_OFN8_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<2>
XU1795 NOR2BX1TR $PINS AN=n1809 B=FE_OFN112_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<1>
XU1796 NOR2BX1TR $PINS AN=n1810 B=FE_OFN8_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<0>
XU1797 NOR2BX1TR $PINS AN=n1811 B=FE_OFN8_reset Y=PE_top0_ST_MULT<2>
XU1798 NOR2BX1TR $PINS AN=n1812 B=FE_OFN8_reset Y=PE_top0_ST_MULT<1>
XU1799 NOR2BX1TR $PINS AN=n1813 B=FE_OFN8_reset Y=PE_top0_ST_MULT<0>
XU1801 NOR2X1TR $PINS A=FE_OFN117_n B=n1803 Y=n2275
XU1802 NOR2BX1TR $PINS AN=n1819 B=FE_OFN117_n Y=n2278
XU1803 NOR2BX1TR $PINS AN=n1818 B=FE_OFN117_n Y=n2277
XU1804 NOR2BX1TR $PINS AN=n1817 B=FE_OFN117_n Y=n2276
XU1805 NOR2BX1TR $PINS AN=pe_in_pk_A__0__0_ B=FE_OFN3_reset
+ Y=pe_in_pk_int_A__0__0_
XU1806 NOR2BX1TR $PINS AN=pe_in_pk_A__0__1_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__1_
XU1807 NOR2BX1TR $PINS AN=pe_in_pk_A__0__2_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__2_
XU1808 NOR2BX1TR $PINS AN=pe_in_pk_A__0__3_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__3_
XU1809 NOR2BX1TR $PINS AN=pe_in_pk_A__0__4_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__4_
XU1810 NOR2BX1TR $PINS AN=pe_in_pk_A__0__5_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__5_
XU1811 NOR2BX1TR $PINS AN=pe_in_pk_A__0__6_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__6_
XU1812 NOR2BX1TR $PINS AN=pe_in_pk_A__0__7_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__0__7_
XU1813 NOR2BX1TR $PINS AN=pe_in_pk_A__1__0_ B=FE_OFN3_reset
+ Y=pe_in_pk_int_A__1__0_
XU1814 NOR2BX1TR $PINS AN=pe_in_pk_A__1__1_ B=FE_OFN3_reset
+ Y=pe_in_pk_int_A__1__1_
XU1815 NOR2BX1TR $PINS AN=pe_in_pk_A__1__2_ B=FE_OFN3_reset
+ Y=pe_in_pk_int_A__1__2_
XU1816 NOR2BX1TR $PINS AN=pe_in_pk_A__1__3_ B=FE_OFN3_reset
+ Y=pe_in_pk_int_A__1__3_
XU1817 NOR2BX1TR $PINS AN=pe_in_pk_A__1__4_ B=FE_OFN6_reset
+ Y=pe_in_pk_int_A__1__4_
XU1818 NOR2BX1TR $PINS AN=pe_in_pk_A__1__5_ B=FE_OFN6_reset
+ Y=pe_in_pk_int_A__1__5_
XU1819 NOR2BX1TR $PINS AN=pe_in_pk_A__1__6_ B=FE_OFN6_reset
+ Y=pe_in_pk_int_A__1__6_
XU1820 NOR2BX1TR $PINS AN=pe_in_pk_A__1__7_ B=FE_OFN6_reset
+ Y=pe_in_pk_int_A__1__7_
XU1821 NOR2BX1TR $PINS AN=pe_in_pk_A__2__0_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__0_
XU1822 NOR2BX1TR $PINS AN=pe_in_pk_A__2__1_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__1_
XU1823 NOR2BX1TR $PINS AN=pe_in_pk_A__2__2_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__2_
XU1824 NOR2BX1TR $PINS AN=pe_in_pk_A__2__3_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__3_
XU1825 NOR2BX1TR $PINS AN=pe_in_pk_A__2__4_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__4_
XU1826 NOR2BX1TR $PINS AN=pe_in_pk_A__2__5_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__5_
XU1827 NOR2BX1TR $PINS AN=pe_in_pk_A__2__6_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__6_
XU1828 NOR2BX1TR $PINS AN=pe_in_pk_A__2__7_ B=FE_OFN4_reset
+ Y=pe_in_pk_int_A__2__7_
XU1829 NOR2BX1TR $PINS AN=pe_in_pk_A__3__0_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__0_
XU1830 NOR2BX1TR $PINS AN=pe_in_pk_A__3__1_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__1_
XU1831 NOR2BX1TR $PINS AN=pe_in_pk_A__3__2_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__2_
XU1832 NOR2BX1TR $PINS AN=pe_in_pk_A__3__3_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__3_
XU1833 NOR2BX1TR $PINS AN=pe_in_pk_A__3__4_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__4_
XU1834 NOR2BX1TR $PINS AN=pe_in_pk_A__3__5_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__5_
XU1835 NOR2BX1TR $PINS AN=pe_in_pk_A__3__6_ B=FE_OFN7_reset
+ Y=pe_in_pk_int_A__3__6_
XU1836 NOR2BX1TR $PINS AN=pe_in_pk_A__3__7_ B=FE_OFN2_reset
+ Y=pe_in_pk_int_A__3__7_
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG76_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n22 CK=CTS_5 Q=n1353
Xclk_r_REG321_S2 DFFQX1TR $PINS D=n2129 CK=CTS_11 Q=n2128
Xclk_r_REG95_S2 DFFQX1TR $PINS D=n2249 CK=CTS_1 Q=n1738
Xclk_r_REG524_S2 DFFQX1TR $PINS D=n2258 CK=CTS_6 Q=n1745
Xclk_r_REG18_S3 DFFQX1TR $PINS D=n1726 CK=CTS_12 Q=n2231
XU1010 XNOR2X1TR $PINS A=n1339 B=n262 Y=n595
XU620 XOR2X1TR $PINS A=n1379 B=n1378 Y=n190
XU769 NAND2X2TR $PINS A=n175 B=n746 Y=n748
XU788 XNOR2X1TR $PINS A=n1384 B=n799 Y=n209
XU776 XNOR2X1TR $PINS A=n1361 B=n743 Y=n412
XU175 INVX2TR $PINS A=pe_in_pk_wrb_addr__2_ Y=n894
XU628 NOR2X1TR $PINS A=n1820 B=n1821 Y=n1072
XU340 NOR2X1TR $PINS A=n815 B=n819 Y=n57
XU796 XOR2X1TR $PINS A=n1394 B=n1393 Y=n212
XU666 NAND2X1TR $PINS A=n590 B=n589 Y=PE_top0_buff_mult_arr0_mult_x_24_n30
XU272 INVX2TR $PINS A=n878 Y=n616
XU312 NAND2X1TR $PINS A=n736 B=n733 Y=n702
Xclk_r_REG541_S1 DFFQX1TR $PINS D=n1451 CK=CTS_11 Q=n1929
XU51 NOR2X1TR $PINS A=PE_top0_buff_mult_arr0_mult_x_24_n29 B=n592 Y=n122
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG446_S2 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<5> CK=CTS_5 Q=n1359
XU778 NAND2X2TR $PINS A=n190 B=n819 Y=n821
XU1152 NAND4X2TR $PINS A=n894 B=n893 C=n892 D=n946 Y=n895
XU73 OR2X2TR $PINS A=n698 B=n697 Y=n733
XU437 OAI21X1TR $PINS A0=n895 A1=FE_PSBN144_n915 B0=FE_OFN115_n Y=n917
XU75 XOR2X1TR $PINS A=n1327 B=n345 Y=n346
XU147 CLKINVX2TR $PINS A=n400 Y=n69
XU217 NAND2X4TR $PINS A=n256 B=n719 Y=n721
XU223 INVX1TR $PINS A=n1056 Y=n1059
XU301 INVX2TR $PINS A=n368 Y=n592
XU528 AND2X1TR $PINS A=n868 B=FE_OFN29_FE_DBTN1_reset Y=pe_out_pk_data__1_
XU606 INVX2TR $PINS A=n1869 Y=n128
XU670 INVX1TR $PINS A=n1353 Y=n532
.ENDS
.GLOBAL VSS
