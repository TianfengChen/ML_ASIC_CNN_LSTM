$ Spice netlist generated by v2lvs
$ v2021.3_15.9    Tue Jul 6 13:44:20 PDT 2021
.INCLUDE "/afs/umich.edu/class/eecs627/ibm13/artisan/current/aci/sc-x/lvs_netlist/ibm13.cdl"
.INCLUDE "/afs/umich.edu/class/eecs627/w23/lab_resource/lab3/reset_driver.cdl"
*.BUSDELIMITER <

.SUBCKT PE_POOL clk reset pe_in_pk_PE_state__2_ pe_in_pk_PE_state__1_
+ pe_in_pk_PE_state__0_ pe_in_pk_A__3__7_ pe_in_pk_A__3__6_ pe_in_pk_A__3__5_
+ pe_in_pk_A__3__4_ pe_in_pk_A__3__3_ pe_in_pk_A__3__2_ pe_in_pk_A__3__1_
+ pe_in_pk_A__3__0_ pe_in_pk_A__2__7_ pe_in_pk_A__2__6_ pe_in_pk_A__2__5_
+ pe_in_pk_A__2__4_ pe_in_pk_A__2__3_ pe_in_pk_A__2__2_ pe_in_pk_A__2__1_
+ pe_in_pk_A__2__0_ pe_in_pk_A__1__7_ pe_in_pk_A__1__6_ pe_in_pk_A__1__5_
+ pe_in_pk_A__1__4_ pe_in_pk_A__1__3_ pe_in_pk_A__1__2_ pe_in_pk_A__1__1_
+ pe_in_pk_A__1__0_ pe_in_pk_A__0__7_ pe_in_pk_A__0__6_ pe_in_pk_A__0__5_
+ pe_in_pk_A__0__4_ pe_in_pk_A__0__3_ pe_in_pk_A__0__2_ pe_in_pk_A__0__1_
+ pe_in_pk_A__0__0_ pe_in_pk_wrb_data__7_ pe_in_pk_wrb_data__6_
+ pe_in_pk_wrb_data__5_ pe_in_pk_wrb_data__4_ pe_in_pk_wrb_data__3_
+ pe_in_pk_wrb_data__2_ pe_in_pk_wrb_data__1_ pe_in_pk_wrb_data__0_
+ pe_in_pk_wrb_addr__3_ pe_in_pk_wrb_addr__2_ pe_in_pk_wrb_addr__1_
+ pe_in_pk_wrb_addr__0_ pe_in_pk_wrb__3_ pe_in_pk_wrb__2_ pe_in_pk_wrb__1_
+ pe_in_pk_wrb__0_ pe_in_pk_rdb_addr__3_ pe_in_pk_rdb_addr__2_
+ pe_in_pk_rdb_addr__1_ pe_in_pk_rdb_addr__0_ pk_out_PE_state__2_
+ pk_out_PE_state__1_ pk_out_PE_state__0_ pk_out_data__7_ pk_out_data__6_
+ pk_out_data__5_ pk_out_data__4_ pk_out_data__3_ pk_out_data__2_
+ pk_out_data__1_ pk_out_data__0_
*.CONNECT pk_out_data__7_ VSS
XPLACEDFE_OCPC231_pe_in_pk_rdb_addr__1 CLKBUFX2TR $PINS A=pe_in_pk_rdb_addr__1_
+ Y=FE_OCPN231_pe_in_pk_rdb_addr__1
XPLACEDFE_OCPC232_pe_in_pk_rdb_addr__2 CLKBUFX2TR $PINS A=pe_in_pk_rdb_addr__2_
+ Y=FE_OCPN150_pe_in_pk_rdb_addr__2
XPLACEDFE_OFC231_n1326 CLKINVX4TR $PINS A=n1326 Y=n408
XCTS_ccl_a_inv_00009 CLKINVX20TR $PINS A=CTS_10 Y=CTS_9
XCTS_ccl_a_inv_00007 CLKINVX20TR $PINS A=CTS_10 Y=CTS_8
XCTS_ccl_a_inv_00003 CLKINVX20TR $PINS A=CTS_10 Y=CTS_12
XCTS_ccl_a_inv_00002 CLKINVX20TR $PINS A=CTS_10 Y=CTS_11
XCTS_ccl_a_inv_00012 CLKINVX20TR $PINS A=CTS_13 Y=CTS_10
XCTS_ccl_a_inv_00008 CLKINVX20TR $PINS A=CTS_5 Y=CTS_4
XCTS_ccl_a_inv_00006 CLKINVX20TR $PINS A=CTS_5 Y=CTS_7
XCTS_ccl_a_inv_00005 CLKINVX20TR $PINS A=CTS_5 Y=CTS_6
XCTS_ccl_a_inv_00011 CLKINVX16TR $PINS A=CTS_13 Y=CTS_5
XCTS_ccl_a_inv_00004 CLKINVX20TR $PINS A=CTS_1 Y=CTS_3
XCTS_ccl_a_inv_00001 CLKINVX20TR $PINS A=CTS_1 Y=CTS_2
XCTS_ccl_a_inv_00010 CLKINVX12TR $PINS A=CTS_13 Y=CTS_1
XCTS_ccl_a_inv_00013 CLKINVX20TR $PINS A=CTS_14 Y=CTS_13
XCTS_ccl_a_inv_00014 CLKINVX8TR $PINS A=clk Y=CTS_14
XPLACEDFE_OCPC230_n206 BUFX3TR $PINS A=n206 Y=FE_OCPN149_n206
XPLACEDFE_OFC229_reset CLKINVX2TR $PINS A=FE_OFN144_reset Y=FE_OFN148_reset
XPLACEDFE_OFC228_reset INVX2TR $PINS A=FE_OFN144_reset Y=FE_OFN147_reset
XPLACEDFE_OFC227_reset CLKINVX4TR $PINS A=FE_OFN27_FE_DBTN3_reset
+ Y=FE_OFN146_reset
XPLACEDFE_OFC226_reset CLKINVX2TR $PINS A=FE_OFN27_FE_DBTN3_reset
+ Y=FE_OFN145_reset
XPLACEDFE_OFC225_reset CLKINVX2TR $PINS A=FE_OFN3_reset Y=FE_OFN144_reset
XPLACEDFE_OFC224_reset CLKINVX2TR $PINS A=FE_DBTN3_reset Y=FE_OFN143_reset
XPLACEDFE_OFC223_reset CLKBUFX2TR $PINS A=FE_DBTN3_reset
+ Y=FE_OFN28_FE_DBTN3_reset
XPLACEDFE_OFC222_reset CLKINVX2TR $PINS A=FE_OFN1_reset
+ Y=FE_OFN27_FE_DBTN3_reset
XPLACEDFE_OFC221_reset CLKBUFX2TR $PINS A=FE_OFN1_reset
+ Y=FE_OFN26_FE_DBTN3_reset
XPLACEDFE_OFC220_reset INVX4TR $PINS A=FE_OFN5_reset Y=FE_OFN3_reset
XPLACEDFE_OFC219_reset CLKINVX2TR $PINS A=FE_OFN5_reset Y=FE_DBTN3_reset
XPLACEDFE_OFC218_reset CLKINVX2TR $PINS A=FE_OFN5_reset Y=FE_OFN2_reset
XPLACEDFE_OFC217_reset CLKBUFX3TR $PINS A=FE_OFN5_reset Y=FE_OFN1_reset
XPLACEDFE_OFC216_reset INVX4TR $PINS A=reset Y=FE_OFN5_reset
XPLACEDFE_OFC215_n881 INVX2TR $PINS A=FE_OFN49_n881 Y=n1011
XPLACEDFE_OFC214_n881 CLKBUFX2TR $PINS A=n881 Y=FE_OFN49_n881
XPLACEDFE_OFC213_n880 INVX2TR $PINS A=FE_OFN48_n880 Y=n1009
XPLACEDFE_OFC212_n880 CLKBUFX2TR $PINS A=n880 Y=FE_OFN48_n880
XPLACEDFE_OFC211_n64 BUFX3TR $PINS A=FE_OFN10_n64 Y=FE_OFN142_n64
XPLACEDFE_OFC210_n64 BUFX6TR $PINS A=n64 Y=FE_OFN10_n64
XPLACEDFE_OFC209_n903 CLKINVX2TR $PINS A=n956 Y=FE_OFN141_n903
XPLACEDFE_OFC208_n903 CLKINVX2TR $PINS A=n956 Y=FE_OFN140_n903
XPLACEDFE_OFC207_n903 CLKINVX2TR $PINS A=n956 Y=FE_OFN139_n903
XPLACEDFE_OFC206_n903 CLKINVX2TR $PINS A=n956 Y=FE_OFN138_n903
XPLACEDFE_OFC205_n903 CLKINVX2TR $PINS A=n903 Y=n956
XPLACEDFE_OFC204_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN137_n901
XPLACEDFE_OFC203_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN136_n901
XPLACEDFE_OFC202_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN135_n901
XPLACEDFE_OFC201_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN134_n901
XPLACEDFE_OFC200_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN133_n901
XPLACEDFE_OFC199_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN132_n901
XPLACEDFE_OFC198_n901 CLKINVX2TR $PINS A=n954 Y=FE_OFN131_n901
XPLACEDFE_OFC197_n901 CLKINVX2TR $PINS A=n901 Y=n954
XPLACEDFE_OFC196_n928 CLKINVX2TR $PINS A=n950 Y=FE_OFN130_n928
XPLACEDFE_OFC195_n928 CLKINVX2TR $PINS A=n950 Y=FE_OFN129_n928
XPLACEDFE_OFC194_n928 CLKINVX2TR $PINS A=n950 Y=FE_OFN128_n928
XPLACEDFE_OFC193_n928 CLKINVX2TR $PINS A=n950 Y=FE_OFN127_n928
XPLACEDFE_OFC192_n928 CLKINVX2TR $PINS A=n950 Y=FE_OFN126_n928
XPLACEDFE_OFC191_n928 INVX2TR $PINS A=n928 Y=n950
XPLACEDFE_OFC190_n902 CLKINVX2TR $PINS A=n960 Y=FE_OFN125_n902
XPLACEDFE_OFC189_n902 CLKINVX2TR $PINS A=n960 Y=FE_OFN124_n902
XPLACEDFE_OFC188_n902 CLKINVX2TR $PINS A=n960 Y=FE_OFN123_n902
XPLACEDFE_OFC187_n902 CLKINVX2TR $PINS A=n960 Y=FE_OFN52_n902
XPLACEDFE_OFC186_n902 CLKINVX2TR $PINS A=n902 Y=n960
XPLACEDFE_OFC185_n884 INVX2TR $PINS A=n1015 Y=FE_OFN122_n884
XPLACEDFE_OFC184_n884 INVX2TR $PINS A=n884 Y=n1015
XPLACEDFE_OFC183_n908 CLKINVX2TR $PINS A=n1007 Y=FE_OFN121_n908
XPLACEDFE_OFC182_n908 CLKINVX2TR $PINS A=n1007 Y=FE_OFN120_n908
XPLACEDFE_OFC181_n908 CLKINVX2TR $PINS A=n1007 Y=FE_OFN119_n908
XPLACEDFE_OFC180_n908 INVX2TR $PINS A=n908 Y=n1007
XPLACEDFE_OFC179_n918 CLKINVX2TR $PINS A=n972 Y=FE_OFN118_n918
XPLACEDFE_OFC178_n918 CLKINVX2TR $PINS A=n972 Y=FE_OFN117_n918
XPLACEDFE_OFC177_n918 CLKINVX2TR $PINS A=n972 Y=FE_OFN116_n918
XPLACEDFE_OFC176_n918 CLKINVX2TR $PINS A=n972 Y=FE_OFN115_n918
XPLACEDFE_OFC175_n918 CLKINVX2TR $PINS A=n972 Y=FE_OFN114_n918
XPLACEDFE_OFC174_n918 INVX2TR $PINS A=n918 Y=n972
XPLACEDFE_OFC173_n909 CLKINVX2TR $PINS A=FE_OFN53_n909 Y=FE_OFN113_n909
XPLACEDFE_OFC172_n909 CLKINVX2TR $PINS A=FE_OFN53_n909 Y=FE_OFN112_n909
XPLACEDFE_OFC171_n909 CLKINVX2TR $PINS A=FE_OFN53_n909 Y=FE_OFN111_n909
XPLACEDFE_OFC170_n909 CLKINVX2TR $PINS A=FE_OFN53_n909 Y=FE_OFN110_n909
XPLACEDFE_OFC169_n909 CLKINVX2TR $PINS A=FE_OFN53_n909 Y=n982
XPLACEDFE_OFC168_n909 INVX2TR $PINS A=n909 Y=FE_OFN53_n909
XPLACEDFE_OFC167_n153 CLKBUFX2TR $PINS A=FE_OFN14_n153 Y=FE_OFN109_n153
XPLACEDFE_OFC166_n153 CLKBUFX2TR $PINS A=FE_OFN14_n153 Y=FE_OFN15_n153
XPLACEDFE_OFC165_n153 CLKBUFX2TR $PINS A=n153 Y=FE_OFN14_n153
XPLACEDFE_OFC164_n890 CLKINVX2TR $PINS A=n997 Y=FE_OFN108_n890
XPLACEDFE_OFC163_n890 INVX2TR $PINS A=n997 Y=FE_OFN107_n890
XPLACEDFE_OFC162_n890 CLKINVX2TR $PINS A=n997 Y=FE_OFN106_n890
XPLACEDFE_OFC161_n890 INVX2TR $PINS A=n890 Y=n997
XPLACEDFE_OFC160_n871 CLKINVX2TR $PINS A=n745 Y=FE_OFN105_n871
XPLACEDFE_OFC159_n871 CLKINVX2TR $PINS A=n745 Y=FE_OFN104_n871
XPLACEDFE_OFC158_n871 INVX2TR $PINS A=n871 Y=n745
XPLACEDFE_OFC157_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN103_n876
XPLACEDFE_OFC156_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN102_n876
XPLACEDFE_OFC155_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN101_n876
XPLACEDFE_OFC154_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN100_n876
XPLACEDFE_OFC153_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN99_n876
XPLACEDFE_OFC152_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN98_n876
XPLACEDFE_OFC151_n876 CLKINVX2TR $PINS A=n986 Y=FE_OFN97_n876
XPLACEDFE_OFC150_n876 INVX2TR $PINS A=n876 Y=n986
XPLACEDFE_OFC149_n877 CLKINVX2TR $PINS A=n988 Y=FE_OFN96_n877
XPLACEDFE_OFC148_n877 INVX2TR $PINS A=n877 Y=n988
XPLACEDFE_OFC147_n935 INVX2TR $PINS A=n978 Y=FE_OFN95_n935
XPLACEDFE_OFC145_n935 INVX2TR $PINS A=n935 Y=n978
XPLACEDFE_OFC144_n922 CLKINVX2TR $PINS A=n992 Y=FE_OFN93_n922
XPLACEDFE_OFC143_n922 CLKINVX2TR $PINS A=n992 Y=FE_OFN92_n922
XPLACEDFE_OFC142_n922 CLKINVX2TR $PINS A=n992 Y=FE_OFN91_n922
XPLACEDFE_OFC141_n922 CLKINVX2TR $PINS A=n992 Y=FE_OFN90_n922
XPLACEDFE_OFC140_n922 CLKINVX2TR $PINS A=n992 Y=FE_OFN89_n922
XPLACEDFE_OFC139_n922 INVX2TR $PINS A=n922 Y=n992
XPLACEDFE_OFC138_n60 BUFX3TR $PINS A=FE_OFN8_n60 Y=FE_OFN88_n60
XPLACEDFE_OFC137_n60 CLKBUFX2TR $PINS A=FE_OFN8_n60 Y=FE_OFN7_n60
XPLACEDFE_OFC136_n60 CLKBUFX2TR $PINS A=n60 Y=FE_OFN8_n60
XPLACEDFE_OFC135_n875 CLKINVX2TR $PINS A=n984 Y=FE_OFN87_n875
XPLACEDFE_OFC134_n875 CLKINVX2TR $PINS A=n984 Y=FE_OFN86_n875
XPLACEDFE_OFC133_n875 CLKINVX2TR $PINS A=n984 Y=FE_OFN85_n875
XPLACEDFE_OFC132_n875 CLKINVX2TR $PINS A=n984 Y=FE_OFN84_n875
XPLACEDFE_OFC131_n875 CLKINVX2TR $PINS A=n984 Y=FE_OFN83_n875
XPLACEDFE_OFC130_n875 INVX2TR $PINS A=n875 Y=n984
XPLACEDFE_OFC129_n916 INVX2TR $PINS A=FE_OFN54_n916 Y=n969
XPLACEDFE_OFC128_n916 CLKBUFX2TR $PINS A=n916 Y=FE_OFN54_n916
XPLACEDFE_OFC127_n2107 BUFX3TR $PINS A=FE_DBTN0_n2107 Y=FE_OFN0_FE_DBTN0_n2107
XPLACEDFE_OFC126_n2107 INVX4TR $PINS A=n2107 Y=FE_DBTN0_n2107
XPLACEDFE_OFC125_n914 CLKINVX2TR $PINS A=n914 Y=FE_OFN82_n914
XPLACEDFE_OFC122_n919 CLKINVX1TR $PINS A=FE_OFN55_n919 Y=FE_OFN80_n919
XPLACEDFE_OFC120_n919 INVX2TR $PINS A=n919 Y=FE_OFN55_n919
XPLACEDFE_OFC119_n147 CLKBUFX2TR $PINS A=FE_OFN11_n147 Y=FE_OFN13_n147
XPLACEDFE_OFC118_n147 CLKBUFX2TR $PINS A=FE_OFN11_n147 Y=FE_OFN12_n147
XPLACEDFE_OFC117_n147 BUFX3TR $PINS A=n147 Y=FE_OFN11_n147
XPLACEDFE_OFC116_n157 INVX4TR $PINS A=FE_OFN24_n157 Y=FE_OFN79_n157
XPLACEDFE_OFC115_n157 INVX2TR $PINS A=FE_OFN24_n157 Y=FE_OFN78_n157
XPLACEDFE_OFC114_n157 CLKINVX2TR $PINS A=FE_OFN25_n157 Y=FE_OFN24_n157
XPLACEDFE_OFC113_n157 CLKBUFX2TR $PINS A=n157 Y=FE_OFN25_n157
XPLACEDFE_OFC112_n926 INVX2TR $PINS A=n980 Y=FE_OFN77_n926
XPLACEDFE_OFC111_n926 INVX2TR $PINS A=n926 Y=n980
XPLACEDFE_OFC110_n920 CLKINVX2TR $PINS A=n976 Y=FE_OFN76_n920
XPLACEDFE_OFC109_n920 CLKINVX2TR $PINS A=n976 Y=FE_OFN75_n920
XPLACEDFE_OFC108_n920 CLKINVX2TR $PINS A=n976 Y=FE_OFN74_n920
XPLACEDFE_OFC107_n920 INVX2TR $PINS A=n920 Y=n976
XPLACEDFE_OFC106_n896 CLKINVX2TR $PINS A=FE_OFN50_n896 Y=FE_OFN73_n896
XPLACEDFE_OFC105_n896 CLKINVX1TR $PINS A=FE_OFN50_n896 Y=FE_OFN72_n896
XPLACEDFE_OFC104_n896 INVX2TR $PINS A=FE_OFN50_n896 Y=n1001
XPLACEDFE_OFC103_n896 INVX2TR $PINS A=n896 Y=FE_OFN50_n896
XPLACEDFE_OFC102_n894 CLKINVX2TR $PINS A=n999 Y=FE_OFN71_n894
XPLACEDFE_OFC101_n894 CLKINVX2TR $PINS A=n999 Y=FE_OFN70_n894
XPLACEDFE_OFC100_n894 CLKINVX2TR $PINS A=n999 Y=FE_OFN69_n894
XPLACEDFE_OFC99_n894 INVX2TR $PINS A=n894 Y=n999
XPLACEDFE_OFC98_n946 BUFX3TR $PINS A=n946 Y=FE_OFN45_n946
XPLACEDFE_OFC97_n946 BUFX3TR $PINS A=n946 Y=FE_OFN44_n946
XPLACEDFE_OFC96_n940 CLKBUFX2TR $PINS A=n940 Y=FE_OFN37_n940
XPLACEDFE_OFC95_n940 BUFX3TR $PINS A=n940 Y=FE_OFN36_n940
XPLACEDFE_OFC94_n899 INVX2TR $PINS A=n899 Y=n1005
XPLACEDFE_OFC93_n897 INVX2TR $PINS A=n1003 Y=FE_OFN68_n897
XPLACEDFE_OFC92_n897 CLKINVX2TR $PINS A=n1003 Y=FE_OFN67_n897
XPLACEDFE_OFC91_n897 CLKINVX2TR $PINS A=n1003 Y=FE_OFN66_n897
XPLACEDFE_OFC90_n897 INVX2TR $PINS A=n897 Y=n1003
XPLACEDFE_OFC89_n945 CLKBUFX2TR $PINS A=n945 Y=FE_OFN42_n945
XPLACEDFE_OFC88_n945 BUFX3TR $PINS A=n945 Y=FE_OFN43_n945
XPLACEDFE_OFC87_n930 INVX2TR $PINS A=n958 Y=FE_OFN65_n930
XPLACEDFE_OFC86_n930 INVX2TR $PINS A=n930 Y=n958
XPLACEDFE_OFC85_n941 BUFX3TR $PINS A=n941 Y=FE_OFN39_n941
XPLACEDFE_OFC84_n941 BUFX3TR $PINS A=n941 Y=FE_OFN38_n941
XPLACEDFE_OFC83_n944 BUFX3TR $PINS A=n944 Y=FE_OFN41_n944
XPLACEDFE_OFC82_n944 BUFX3TR $PINS A=n944 Y=FE_OFN40_n944
XPLACEDFE_OFC81_n155 CLKINVX2TR $PINS A=FE_OFN19_n155 Y=FE_OFN64_n155
XPLACEDFE_OFC80_n155 INVX2TR $PINS A=FE_OFN19_n155 Y=FE_OFN18_n155
XPLACEDFE_OFC79_n155 CLKINVX2TR $PINS A=n155 Y=FE_OFN19_n155
XPLACEDFE_OFC78_n155 CLKBUFX2TR $PINS A=n155 Y=FE_OFN20_n155
XPLACEDFE_OFC77_n886 INVX2TR $PINS A=n1017 Y=FE_OFN63_n886
XPLACEDFE_OFC76_n886 INVX2TR $PINS A=n886 Y=n1017
XPLACEDFE_OFC75_n924 INVX2TR $PINS A=n924 Y=n994
XPLACEDFE_OFC74_n887 INVX2TR $PINS A=n1019 Y=FE_OFN62_n887
XPLACEDFE_OFC73_n887 INVX2TR $PINS A=n887 Y=n1019
XPLACEDFE_OFC72_n947 CLKBUFX2TR $PINS A=n947 Y=FE_OFN61_n947
XPLACEDFE_OFC71_n947 CLKBUFX2TR $PINS A=n947 Y=FE_OFN47_n947
XPLACEDFE_OFC70_n947 CLKBUFX2TR $PINS A=n947 Y=FE_OFN46_n947
XPLACEDFE_OFC69_n156 INVX2TR $PINS A=FE_OFN22_n156 Y=FE_OFN60_n156
XPLACEDFE_OFC68_n156 CLKINVX2TR $PINS A=FE_OFN22_n156 Y=FE_OFN23_n156
XPLACEDFE_OFC67_n156 CLKINVX2TR $PINS A=n156 Y=FE_OFN22_n156
XPLACEDFE_OFC66_n156 CLKBUFX2TR $PINS A=n156 Y=FE_OFN21_n156
XPLACEDFE_OFC65_n882 INVX2TR $PINS A=FE_OFN32_n882 Y=FE_OFN59_n882
XPLACEDFE_OFC64_n882 INVX2TR $PINS A=FE_OFN32_n882 Y=FE_OFN58_n882
XPLACEDFE_OFC63_n882 CLKINVX2TR $PINS A=n882 Y=FE_OFN32_n882
XPLACEDFE_OFC62_n882 CLKBUFX2TR $PINS A=n882 Y=FE_OFN33_n882
XPLACEDFE_OFC61_n938 BUFX3TR $PINS A=FE_OFN35_n938 Y=FE_OFN57_n938
XPLACEDFE_OFC60_n938 CLKINVX2TR $PINS A=FE_OFN34_n938 Y=FE_OFN56_n938
XPLACEDFE_OFC59_n938 INVX4TR $PINS A=FE_OFN34_n938 Y=FE_OFN35_n938
XPLACEDFE_OFC58_n938 CLKINVX2TR $PINS A=n938 Y=FE_OFN34_n938
XPLACEDFE_OFC57_n154 CLKBUFX2TR $PINS A=n154 Y=FE_OFN16_n154
XPLACEDFE_OFC56_n154 CLKBUFX2TR $PINS A=n154 Y=FE_OFN17_n154
XPLACEDFE_OFC31_FE_DBTN3_reset CLKBUFX2TR $PINS A=FE_OFN1_reset
+ Y=FE_OFN31_FE_DBTN3_reset
XPLACEDFE_OFC30_FE_DBTN3_reset CLKBUFX2TR $PINS A=FE_OFN1_reset
+ Y=FE_OFN30_FE_DBTN3_reset
XPLACEDFE_OFC29_FE_DBTN3_reset BUFX4TR $PINS A=FE_OFN146_reset
+ Y=FE_OFN29_FE_DBTN3_reset
XPLACEDFE_OFC9_n64 CLKBUFX2TR $PINS A=n64 Y=FE_OFN9_n64
XPLACEDFE_OFC6_reset BUFX4TR $PINS A=FE_OFN4_reset Y=FE_OFN6_reset
XPLACEDFE_OFC4_reset BUFX3TR $PINS A=FE_OFN3_reset Y=FE_OFN4_reset
XPLACEDFE_DBTC2_pe_in_pk_wrb_addr__0 INVX2TR $PINS A=pe_in_pk_wrb_addr__0_
+ Y=FE_DBTN2_pe_in_pk_wrb_addr__0
XPLACEDFE_DBTC1_n1325 INVX2TR $PINS A=n1325 Y=FE_DBTN1_n1325
Xclk_r_REG4_S3 DFFQX1TR $PINS D=n1671 CK=CTS_9 Q=n2144
Xclk_r_REG27_S3 DFFQX1TR $PINS D=n1669 CK=CTS_9 Q=n2142
Xclk_r_REG538_S1 DFFQX1TR $PINS D=n1667 CK=CTS_7 Q=n2140
Xclk_r_REG537_S1 DFFQX1TR $PINS D=n1666 CK=CTS_7 Q=n2139
Xclk_r_REG536_S1 DFFQX1TR $PINS D=n1665 CK=CTS_8 Q=n2138
Xclk_r_REG535_S1 DFFQX1TR $PINS D=n1664 CK=CTS_8 Q=n2137
Xclk_r_REG534_S1 DFFQX1TR $PINS D=n1663 CK=CTS_8 Q=n2136
Xclk_r_REG533_S1 DFFQX1TR $PINS D=n1662 CK=CTS_8 Q=n2135
Xclk_r_REG532_S1 DFFQX1TR $PINS D=n1661 CK=CTS_6 Q=n2134
Xclk_r_REG549_S1 DFFQX1TR $PINS D=n1659 CK=CTS_3 Q=n2132
Xclk_r_REG548_S1 DFFQX1TR $PINS D=n1658 CK=CTS_8 Q=n2131
Xclk_r_REG547_S1 DFFQX1TR $PINS D=n1657 CK=CTS_3 Q=n2130
Xclk_r_REG546_S1 DFFQX1TR $PINS D=n1656 CK=CTS_3 Q=n2129
Xclk_r_REG545_S1 DFFQX1TR $PINS D=n1655 CK=CTS_6 Q=n2128
Xclk_r_REG544_S1 DFFQX1TR $PINS D=n1654 CK=CTS_6 Q=n2127
Xclk_r_REG543_S1 DFFQX1TR $PINS D=n1653 CK=CTS_4 Q=n2126
Xclk_r_REG542_S1 DFFQX1TR $PINS D=n1652 CK=CTS_4 Q=n2125
Xclk_r_REG541_S1 DFFQX1TR $PINS D=n1651 CK=CTS_4 Q=n2124
Xclk_r_REG540_S1 DFFQX1TR $PINS D=n1650 CK=CTS_7 Q=n2123
Xclk_r_REG539_S1 DFFQX1TR $PINS D=n1649 CK=CTS_6 Q=n2122
Xclk_r_REG524_S1 DFFQX1TR $PINS D=n1648 CK=CTS_6 Q=n2121
Xclk_r_REG523_S1 DFFQX1TR $PINS D=n1647 CK=CTS_12 Q=n2120
Xclk_r_REG522_S1 DFFQX1TR $PINS D=n1646 CK=CTS_6 Q=n2119
Xclk_r_REG520_S1 DFFQX1TR $PINS D=n1644 CK=CTS_6 Q=n2117
Xclk_r_REG519_S1 DFFQX1TR $PINS D=n1643 CK=CTS_6 Q=n2116
Xclk_r_REG518_S1 DFFQX1TR $PINS D=n1642 CK=CTS_6 Q=n2115
Xclk_r_REG517_S1 DFFQX1TR $PINS D=n1641 CK=CTS_6 Q=n2114
Xclk_r_REG516_S1 DFFQX1TR $PINS D=n1640 CK=CTS_6 Q=n2113
Xclk_r_REG514_S1 DFFQX1TR $PINS D=n1638 CK=CTS_6 Q=n2111
Xclk_r_REG513_S1 DFFQX1TR $PINS D=n1637 CK=CTS_12 Q=n2110
Xclk_r_REG528_S1 DFFQX1TR $PINS D=n1636 CK=CTS_6 Q=n2109
Xclk_r_REG527_S1 DFFQX1TR $PINS D=n1635 CK=CTS_7 Q=n2108
Xclk_r_REG128_S1 DFFQX1TR $PINS D=n1633 CK=CTS_6 Q=n2105
Xclk_r_REG0_S1 DFFQX1TR $PINS D=n1632 CK=CTS_8 Q=n2104
Xclk_r_REG471_S1 DFFQX1TR $PINS D=n1631 CK=CTS_12 Q=n2103
Xclk_r_REG469_S1 DFFQX1TR $PINS D=n1629 CK=CTS_12 Q=n2100
Xclk_r_REG489_S1 DFFQX1TR $PINS D=n1627 CK=CTS_6 Q=n2098
Xclk_r_REG487_S1 DFFQX1TR $PINS D=n1625 CK=CTS_4 Q=n2095
Xclk_r_REG480_S1 DFFQX1TR $PINS D=n1618 CK=CTS_4 Q=n2088
Xclk_r_REG507_S1 DFFQX1TR $PINS D=n1610 CK=CTS_3 Q=n2079
Xclk_r_REG504_S1 DFFQX1TR $PINS D=n1607 CK=CTS_3 Q=n2075
Xclk_r_REG496_S1 DFFQX1TR $PINS D=n1599 CK=CTS_4 Q=n2067
Xclk_r_REG493_S1 DFFQX1TR $PINS D=n1596 CK=CTS_4 Q=n2064
Xclk_r_REG427_S1 DFFQX1TR $PINS D=n1595 CK=CTS_12 Q=n2063
Xclk_r_REG425_S1 DFFQX1TR $PINS D=n1593 CK=CTS_12 Q=n2060
Xclk_r_REG445_S1 DFFQX1TR $PINS D=n1591 CK=CTS_6 Q=n2058
Xclk_r_REG443_S1 DFFQX1TR $PINS D=n1589 CK=CTS_4 Q=n2055
Xclk_r_REG436_S1 DFFQX1TR $PINS D=n1582 CK=CTS_7 Q=n2048
Xclk_r_REG465_S2 DFFQX1TR $PINS D=n2041 CK=CTS_9 Q=n2040
Xclk_r_REG463_S1 DFFQX1TR $PINS D=n1574 CK=CTS_3 Q=n2039
Xclk_r_REG460_S1 DFFQX1TR $PINS D=n1571 CK=CTS_3 Q=n2035
Xclk_r_REG452_S1 DFFQX1TR $PINS D=n1563 CK=CTS_4 Q=n2027
Xclk_r_REG449_S1 DFFQX1TR $PINS D=n1560 CK=CTS_4 Q=n2024
Xclk_r_REG383_S1 DFFQX1TR $PINS D=n1559 CK=CTS_12 Q=n2023
Xclk_r_REG381_S1 DFFQX1TR $PINS D=n1557 CK=CTS_6 Q=n2020
Xclk_r_REG401_S1 DFFQX1TR $PINS D=n1555 CK=CTS_2 Q=n2018
Xclk_r_REG399_S1 DFFQX1TR $PINS D=n1553 CK=CTS_4 Q=n2015
Xclk_r_REG392_S1 DFFQX1TR $PINS D=n1546 CK=CTS_4 Q=n2008
Xclk_r_REG419_S1 DFFQX1TR $PINS D=n1538 CK=CTS_3 Q=n1999
Xclk_r_REG417_S1 DFFQX1TR $PINS D=n1536 CK=CTS_7 Q=n1996
Xclk_r_REG416_S1 DFFQX1TR $PINS D=n1535 CK=CTS_3 Q=n1995
Xclk_r_REG415_S1 DFFQX1TR $PINS D=n1534 CK=CTS_3 Q=n1994
Xclk_r_REG408_S1 DFFQX1TR $PINS D=n1527 CK=CTS_4 Q=n1987
Xclk_r_REG405_S1 DFFQX1TR $PINS D=n1524 CK=CTS_4 Q=n1984
Xclk_r_REG339_S1 DFFQX1TR $PINS D=n1523 CK=CTS_9 Q=n1983
Xclk_r_REG337_S1 DFFQX1TR $PINS D=n1521 CK=CTS_6 Q=n1980
Xclk_r_REG357_S1 DFFQX1TR $PINS D=n1519 CK=CTS_2 Q=n1978
Xclk_r_REG355_S1 DFFQX1TR $PINS D=n1517 CK=CTS_4 Q=n1975
Xclk_r_REG348_S1 DFFQX1TR $PINS D=n1510 CK=CTS_4 Q=n1968
Xclk_r_REG377_S2 DFFQX1TR $PINS D=n1961 CK=CTS_9 Q=n1960
Xclk_r_REG375_S1 DFFQX1TR $PINS D=n1502 CK=CTS_3 Q=n1959
Xclk_r_REG373_S1 DFFQX1TR $PINS D=n1500 CK=CTS_8 Q=n1956
Xclk_r_REG372_S1 DFFQX1TR $PINS D=n1499 CK=CTS_3 Q=n1955
Xclk_r_REG371_S1 DFFQX1TR $PINS D=n1498 CK=CTS_3 Q=n1954
Xclk_r_REG364_S1 DFFQX1TR $PINS D=n1491 CK=CTS_4 Q=n1947
Xclk_r_REG361_S1 DFFQX1TR $PINS D=n1488 CK=CTS_4 Q=n1944
Xclk_r_REG295_S1 DFFQX1TR $PINS D=n1487 CK=CTS_12 Q=n1943
Xclk_r_REG293_S1 DFFQX1TR $PINS D=n1485 CK=CTS_12 Q=n1940
Xclk_r_REG313_S1 DFFQX1TR $PINS D=n1483 CK=CTS_3 Q=n1938
Xclk_r_REG311_S1 DFFQX1TR $PINS D=n1481 CK=CTS_4 Q=n1935
Xclk_r_REG308_S1 DFFQX1TR $PINS D=n1478 CK=CTS_7 Q=n1932
Xclk_r_REG307_S1 DFFQX1TR $PINS D=n1477 CK=CTS_7 Q=n1931
Xclk_r_REG306_S1 DFFQX1TR $PINS D=n1476 CK=CTS_7 Q=n1930
Xclk_r_REG305_S1 DFFQX1TR $PINS D=n1475 CK=CTS_7 Q=n1929
Xclk_r_REG304_S1 DFFQX1TR $PINS D=n1474 CK=CTS_4 Q=n1928
Xclk_r_REG302_S1 DFFQX1TR $PINS D=n1472 CK=CTS_6 Q=n1926
Xclk_r_REG300_S1 DFFQX1TR $PINS D=n1470 CK=CTS_12 Q=n1924
Xclk_r_REG299_S1 DFFQX1TR $PINS D=n1469 CK=CTS_12 Q=n1923
Xclk_r_REG298_S1 DFFQX1TR $PINS D=n1468 CK=CTS_12 Q=n1922
Xclk_r_REG331_S1 DFFQX1TR $PINS D=n1466 CK=CTS_3 Q=n1919
Xclk_r_REG329_S1 DFFQX1TR $PINS D=n1464 CK=CTS_8 Q=n1916
Xclk_r_REG328_S1 DFFQX1TR $PINS D=n1463 CK=CTS_3 Q=n1915
Xclk_r_REG327_S1 DFFQX1TR $PINS D=n1462 CK=CTS_3 Q=n1914
Xclk_r_REG320_S1 DFFQX1TR $PINS D=n1455 CK=CTS_4 Q=n1907
Xclk_r_REG317_S1 DFFQX1TR $PINS D=n1452 CK=CTS_4 Q=n1904
Xclk_r_REG251_S1 DFFQX1TR $PINS D=n1451 CK=CTS_12 Q=n1903
Xclk_r_REG252_S2 DFFQX1TR $PINS D=n1903 CK=CTS_12 Q=n1902
Xclk_r_REG249_S1 DFFQX1TR $PINS D=n1449 CK=CTS_12 Q=n1900
Xclk_r_REG269_S1 DFFQX1TR $PINS D=n1447 CK=CTS_6 Q=n1898
Xclk_r_REG267_S1 DFFQX1TR $PINS D=n1445 CK=CTS_4 Q=n1895
Xclk_r_REG266_S1 DFFQX1TR $PINS D=n1444 CK=CTS_7 Q=n1894
Xclk_r_REG264_S1 DFFQX1TR $PINS D=n1442 CK=CTS_7 Q=n1892
Xclk_r_REG263_S1 DFFQX1TR $PINS D=n1441 CK=CTS_7 Q=n1891
Xclk_r_REG262_S1 DFFQX1TR $PINS D=n1440 CK=CTS_7 Q=n1890
Xclk_r_REG261_S1 DFFQX1TR $PINS D=n1439 CK=CTS_7 Q=n1889
Xclk_r_REG260_S1 DFFQX1TR $PINS D=n1438 CK=CTS_7 Q=n1888
Xclk_r_REG258_S1 DFFQX1TR $PINS D=n1436 CK=CTS_6 Q=n1886
Xclk_r_REG256_S1 DFFQX1TR $PINS D=n1434 CK=CTS_12 Q=n1884
Xclk_r_REG255_S1 DFFQX1TR $PINS D=n1433 CK=CTS_12 Q=n1883
Xclk_r_REG254_S1 DFFQX1TR $PINS D=n1432 CK=CTS_12 Q=n1882
Xclk_r_REG289_S2 DFFQX1TR $PINS D=n1881 CK=CTS_9 Q=n1880
Xclk_r_REG287_S1 DFFQX1TR $PINS D=n1430 CK=CTS_3 Q=n1879
Xclk_r_REG286_S1 DFFQX1TR $PINS D=n1429 CK=CTS_7 Q=n1877
Xclk_r_REG285_S1 DFFQX1TR $PINS D=n1428 CK=CTS_7 Q=n1876
Xclk_r_REG284_S1 DFFQX1TR $PINS D=n1427 CK=CTS_3 Q=n1875
Xclk_r_REG283_S1 DFFQX1TR $PINS D=n1426 CK=CTS_3 Q=n1874
Xclk_r_REG276_S1 DFFQX1TR $PINS D=n1419 CK=CTS_4 Q=n1867
Xclk_r_REG274_S1 DFFQX1TR $PINS D=n1417 CK=CTS_4 Q=n1865
Xclk_r_REG273_S1 DFFQX1TR $PINS D=n1416 CK=CTS_4 Q=n1864
Xclk_r_REG207_S1 DFFQX1TR $PINS D=n1415 CK=CTS_12 Q=n1863
Xclk_r_REG205_S1 DFFQX1TR $PINS D=n1413 CK=CTS_12 Q=n1860
Xclk_r_REG204_S1 DFFQX1TR $PINS D=n1412 CK=CTS_2 Q=n1859
Xclk_r_REG225_S1 DFFQX1TR $PINS D=n1411 CK=CTS_2 Q=n1858
Xclk_r_REG224_S1 DFFQX1TR $PINS D=n1410 CK=CTS_4 Q=n1856
Xclk_r_REG223_S1 DFFQX1TR $PINS D=n1409 CK=CTS_4 Q=n1855
Xclk_r_REG222_S1 DFFQX1TR $PINS D=n1408 CK=CTS_6 Q=n1854
Xclk_r_REG220_S1 DFFQX1TR $PINS D=n1406 CK=CTS_6 Q=n1852
Xclk_r_REG219_S1 DFFQX1TR $PINS D=n1405 CK=CTS_6 Q=n1851
Xclk_r_REG218_S1 DFFQX1TR $PINS D=n1404 CK=CTS_7 Q=n1850
Xclk_r_REG217_S1 DFFQX1TR $PINS D=n1403 CK=CTS_6 Q=n1849
Xclk_r_REG216_S1 DFFQX1TR $PINS D=n1402 CK=CTS_7 Q=n1848
Xclk_r_REG215_S1 DFFQX1TR $PINS D=n1401 CK=CTS_7 Q=n1847
Xclk_r_REG214_S1 DFFQX1TR $PINS D=n1400 CK=CTS_6 Q=n1846
Xclk_r_REG212_S1 DFFQX1TR $PINS D=n1398 CK=CTS_12 Q=n1844
Xclk_r_REG211_S1 DFFQX1TR $PINS D=n1397 CK=CTS_12 Q=n1843
Xclk_r_REG210_S1 DFFQX1TR $PINS D=n1396 CK=CTS_8 Q=n1842
Xclk_r_REG243_S1 DFFQX1TR $PINS D=n1394 CK=CTS_3 Q=n1839
Xclk_r_REG242_S1 DFFQX1TR $PINS D=n1393 CK=CTS_8 Q=n1837
Xclk_r_REG241_S1 DFFQX1TR $PINS D=n1392 CK=CTS_8 Q=n1836
Xclk_r_REG240_S1 DFFQX1TR $PINS D=n1391 CK=CTS_3 Q=n1835
Xclk_r_REG239_S1 DFFQX1TR $PINS D=n1390 CK=CTS_3 Q=n1834
Xclk_r_REG234_S1 DFFQX1TR $PINS D=n1385 CK=CTS_8 Q=n1829
Xclk_r_REG233_S1 DFFQX1TR $PINS D=n1384 CK=CTS_8 Q=n1828
Xclk_r_REG232_S1 DFFQX1TR $PINS D=n1383 CK=CTS_4 Q=n1827
Xclk_r_REG231_S1 DFFQX1TR $PINS D=n1382 CK=CTS_4 Q=n1826
Xclk_r_REG230_S1 DFFQX1TR $PINS D=n1381 CK=CTS_4 Q=n1825
Xclk_r_REG229_S1 DFFQX1TR $PINS D=n1380 CK=CTS_4 Q=n1824
Xclk_r_REG164_S2 DFFQX1TR $PINS D=n1823 CK=CTS_12 Q=n1822
Xclk_r_REG201_S2 DFFQX1TR $PINS D=n1801 CK=CTS_9 Q=n1800
Xclk_r_REG188_S1 DFFQX1TR $PINS D=n1347 CK=CTS_4 Q=n1787
Xclk_r_REG185_S1 DFFQX1TR $PINS D=n1344 CK=CTS_4 Q=n1784
Xclk_r_REG11_S1 DFFQX1TR $PINS D=n1339 CK=CTS_9 Q=n1783
Xclk_r_REG531_S1 DFFQX1TR $PINS D=FE_OFN144_reset CK=CTS_11 Q=n1778
Xclk_r_REG82_S1 DFFQX1TR $PINS D=FE_OFN147_reset CK=CTS_11 Q=n1777
Xclk_r_REG69_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out_int_4_
+ CK=CTS_11 Q=n1776
Xclk_r_REG100_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<4>
+ CK=CTS_2 Q=n1773
Xclk_r_REG87_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<4>
+ CK=CTS_11 Q=n1771
Xclk_r_REG62_S3 DFFQX1TR $PINS D=PE_top0_ST_ADD<0> CK=CTS_11 Q=n1766
Xclk_r_REG63_S4 DFFQX1TR $PINS D=pe_out_pk_PE_state__0_ CK=CTS_9 Q=n1763
Xclk_r_REG57_S3 DFFQX1TR $PINS D=pe_out_pk_PE_state__1_ CK=CTS_9 Q=n1762
Xclk_r_REG51_S3 DFFQX1TR $PINS D=pe_out_pk_PE_state__2_ CK=CTS_11 Q=n1761
Xclk_r_REG61_S2 DFFQX1TR $PINS D=PE_top0_ST_MULT<0> CK=CTS_11 Q=n1760
Xclk_r_REG55_S1 DFFQX1TR $PINS D=PE_top0_ST_MULT<1> CK=CTS_11 Q=n1759
Xclk_r_REG49_S1 DFFQX1TR $PINS D=PE_top0_ST_MULT<2> CK=CTS_11 Q=n1758
Xclk_r_REG60_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<0> CK=CTS_2
+ Q=n1757
Xclk_r_REG54_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<1> CK=CTS_2
+ Q=n1756
Xclk_r_REG48_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int2<2> CK=CTS_2
+ Q=n1755
Xclk_r_REG59_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<0> CK=CTS_3
+ Q=n1754
Xclk_r_REG53_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<1> CK=CTS_3
+ Q=n1753
Xclk_r_REG47_S1 DFFQX1TR $PINS D=PE_top0_buff_mult_arr0_state_int1<2> CK=CTS_3
+ Q=n1752
Xclk_r_REG21_S3 DFFQX1TR $PINS D=n1342 CK=CTS_9 Q=n1750
Xclk_r_REG39_S3 DFFQX1TR $PINS D=n1341 CK=CTS_9 Q=n1749
Xclk_r_REG3_S3 DFFQX1TR $PINS D=pe_out_pk_data__7_ CK=CTS_9 Q=n1747
Xclk_r_REG8_S3 DFFQX1TR $PINS D=pe_out_pk_data__6_ CK=CTS_9 Q=n1746
Xclk_r_REG14_S3 DFFQX1TR $PINS D=pe_out_pk_data__5_ CK=CTS_9 Q=n1744
Xclk_r_REG20_S3 DFFQX1TR $PINS D=pe_out_pk_data__4_ CK=CTS_9 Q=n1742
Xclk_r_REG26_S3 DFFQX1TR $PINS D=pe_out_pk_data__3_ CK=CTS_9 Q=n1740
Xclk_r_REG32_S3 DFFQX1TR $PINS D=pe_out_pk_data__2_ CK=CTS_9 Q=n1738
Xclk_r_REG38_S3 DFFQX1TR $PINS D=pe_out_pk_data__1_ CK=CTS_9 Q=n1736
Xclk_r_REG44_S3 DFFQX1TR $PINS D=pe_out_pk_data__0_ CK=CTS_9 Q=n1734
Xclk_r_REG2_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<7> CK=CTS_9 Q=n1732
Xclk_r_REG7_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<6> CK=CTS_9 Q=n1731
Xclk_r_REG25_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<3> CK=CTS_9 Q=n1728
Xclk_r_REG31_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<2> CK=CTS_9 Q=n1727
Xclk_r_REG37_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<1> CK=CTS_9 Q=n1726
Xclk_r_REG88_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out1_0_ CK=CTS_11
+ Q=n1724
Xclk_r_REG101_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out1_0_ CK=CTS_12
+ Q=n1723
Xclk_r_REG70_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out1_0_ CK=CTS_11
+ Q=n1721
Xclk_r_REG42_S1 DFFQX1TR $PINS D=PE_top0_adder0_out_int2<0> CK=CTS_9 Q=n1720
Xclk_r_REG30_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n35 CK=CTS_9
+ Q=n1718
Xclk_r_REG35_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n34 CK=CTS_9
+ Q=n1717
Xclk_r_REG18_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n28 CK=CTS_9
+ Q=n1714
Xclk_r_REG41_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n37 CK=CTS_9
+ Q=n1704
Xclk_r_REG467_S2 DFFQX1TR $PINS D=n2185 CK=CTS_8 Q=n1702
Xclk_r_REG379_S2 DFFQX1TR $PINS D=n2183 CK=CTS_8 Q=n1700
Xclk_r_REG335_S2 DFFQX1TR $PINS D=n2182 CK=CTS_8 Q=n1699
Xclk_r_REG291_S2 DFFQX1TR $PINS D=n2181 CK=CTS_8 Q=n1698
Xclk_r_REG203_S2 DFFQX1TR $PINS D=n2178 CK=CTS_8 Q=n1696
Xclk_r_REG404_S2 DFFQX1TR $PINS D=n2164 CK=CTS_6 Q=n1685
Xclk_r_REG228_S2 DFFQX1TR $PINS D=n2160 CK=CTS_6 Q=n1681
Xclk_r_REG429_S2 DFFQX1TR $PINS D=n2155 CK=CTS_12 Q=n1678
Xclk_r_REG385_S2 DFFQX1TR $PINS D=n2154 CK=CTS_2 Q=n1677
Xclk_r_REG253_S2 DFFQX1TR $PINS D=n2151 CK=CTS_12 Q=n1674
Xclk_r_REG165_S2 DFFQX1TR $PINS D=n2148 CK=CTS_12 Q=n1672
Xclk_r_REG83_S1 DFFHQX2TR $PINS D=n2147 CK=CTS_12 Q=n1708
Xclk_r_REG526_S2 DFFHQX2TR $PINS D=n2149 CK=CTS_12 Q=n1782
Xclk_r_REG525_S2 DFFHQX2TR $PINS D=n2159 CK=CTS_6 Q=n1781
Xclk_r_REG530_S1 DFFHQX2TR $PINS D=n2179 CK=CTS_9 Q=n1779
Xclk_r_REG97_S1 DFFHQX2TR $PINS D=n2157 CK=CTS_6 Q=n1707
Xclk_r_REG65_S2 DFFHQX2TR $PINS D=n2177 CK=CTS_8 Q=n1705
Xclk_r_REG529_S1 DFFHQX2TR $PINS D=n2169 CK=CTS_3 Q=n1780
Xclk_r_REG112_S1 DFFQX4TR $PINS D=n2167 CK=CTS_3 Q=n1706
Xclk_r_REG52_S4 DFFQX1TR $PINS D=n2188 CK=CTS_11 Q=pk_out_PE_state__2_
Xclk_r_REG58_S4 DFFQX1TR $PINS D=n2189 CK=CTS_11 Q=pk_out_PE_state__1_
Xclk_r_REG64_S5 DFFQX1TR $PINS D=n2190 CK=CTS_11 Q=pk_out_PE_state__0_
Xclk_r_REG5_S4 DFFQX1TR $PINS D=n2187 CK=CTS_9 Q=n1767
Xclk_r_REG10_S4 DFFQX1TR $PINS D=n1746 CK=CTS_9 Q=n1745
Xclk_r_REG16_S4 DFFQX1TR $PINS D=n1744 CK=CTS_9 Q=n1743
Xclk_r_REG22_S4 DFFQX1TR $PINS D=n1742 CK=CTS_9 Q=n1741
Xclk_r_REG28_S4 DFFQX1TR $PINS D=n1740 CK=CTS_9 Q=n1739
Xclk_r_REG34_S4 DFFQX1TR $PINS D=n1738 CK=CTS_9 Q=n1737
Xclk_r_REG40_S4 DFFQX1TR $PINS D=n1736 CK=CTS_9 Q=n1735
Xclk_r_REG46_S4 DFFQX1TR $PINS D=n1734 CK=CTS_9 Q=n1733
Xclk_r_REG247_S2 DFFQX1TR $PINS D=n2180 CK=CTS_8 Q=n1697
Xclk_r_REG315_S2 DFFQX1TR $PINS D=n2172 CK=CTS_3 Q=n1691
Xclk_r_REG245_S2 DFFQX1TR $PINS D=n1841 CK=CTS_9 Q=n1840
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG68_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n39 CK=CTS_11 Q=n1338
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG76_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n22 CK=CTS_11 Q=n1330
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG134_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<0> CK=CTS_11 Q=n1326
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG139_S1 DFFHQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<1> CK=CTS_11 Q=n1325
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG132_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<2> CK=CTS_11 Q=n1324
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG131_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<3> CK=CTS_11 Q=n1323
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG133_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<6> CK=CTS_11 Q=n1320
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG512_S1 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<7> CK=CTS_11 Q=n1319
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG126_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n19 CK=CTS_2 Q=n1307
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG123_S2 DFFHQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n22 CK=CTS_2 Q=n1313
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG119_S2 DFFHQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n24 CK=CTS_2 Q=n1312
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG122_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n5 CK=CTS_2 Q=n1309
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG142_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<1> CK=CTS_3 Q=n1304
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG141_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<2> CK=CTS_3 Q=n1303
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG140_S1 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<3> CK=CTS_3 Q=n1302
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG138_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<4> CK=CTS_3 Q=n1301
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG137_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<5> CK=CTS_3 Q=n1300
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG136_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<6> CK=CTS_3 Q=n1299
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG150_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<1> CK=CTS_2 Q=n1284
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG106_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n22 CK=CTS_2 Q=n1294
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG103_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n30 CK=CTS_2 Q=n1292
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG105_S2 DFFHQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n26 CK=CTS_2 Q=n1289
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG108_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n19 CK=CTS_2 Q=n1287
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG146_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<5> CK=CTS_2 Q=n1280
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG144_S1 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<7> CK=CTS_2 Q=n1278
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG89_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n29 CK=CTS_11 Q=n1276
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG90_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n30 CK=CTS_11 Q=n1275
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG91_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n5 CK=CTS_11 Q=n1274
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG92_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n23 CK=CTS_11 Q=n1273
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG93_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n22 CK=CTS_11 Q=n1272
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG85_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n31 CK=CTS_11 Q=n1268
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG155_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<4> CK=CTS_11 Q=n1263
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG154_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<5> CK=CTS_11 Q=n1262
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG153_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<6> CK=CTS_2 Q=n1261
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG152_S1 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<7> CK=CTS_2 Q=n1260
Xclk_r_REG36_S1 DFFQX1TR $PINS D=PE_top0_adder0_out_int2<1> CK=CTS_9 Q=n1719
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG135_S1 DFFQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<7> CK=CTS_3 Q=n1298
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG95_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n19 CK=CTS_2 Q=n1270
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG75_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n23 CK=CTS_11 Q=n1331
Xclk_r_REG99_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<5>
+ CK=CTS_2 Q=n1774
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG66_S3 DFFHQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n1 CK=CTS_11 Q=n1337
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG98_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n32 CK=CTS_2 Q=n1296
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG127_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n2 CK=CTS_2 Q=n1306
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG124_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n23 CK=CTS_2 Q=n1314
Xclk_r_REG1_S1 DFFHQX4TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n2 CK=CTS_11
+ Q=n1709
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG107_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n23 CK=CTS_2 Q=n1288
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG84_S2 DFFHQX2TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n1 CK=CTS_11 Q=n1277
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG113_S2 DFFHQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n32 CK=CTS_2 Q=n1317
Xclk_r_REG509_S2 DFFQX1TR $PINS D=n2081 CK=CTS_9 Q=n2080
Xclk_r_REG270_S2 DFFQX1TR $PINS D=n1898 CK=CTS_6 Q=n1897
Xclk_r_REG360_S2 DFFQX1TR $PINS D=n2163 CK=CTS_6 Q=n1684
Xclk_r_REG86_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<5>
+ CK=CTS_11 Q=n1772
Xclk_r_REG476_S1 DFFQX1TR $PINS D=n1614 CK=CTS_6 Q=n2084
Xclk_r_REG352_S1 DFFQX1TR $PINS D=n1514 CK=CTS_7 Q=n1972
Xclk_r_REG462_S1 DFFQX1TR $PINS D=n1573 CK=CTS_8 Q=n2037
Xclk_r_REG453_S1 DFFQX1TR $PINS D=n1564 CK=CTS_8 Q=n2028
Xclk_r_REG321_S1 DFFQX1TR $PINS D=n1456 CK=CTS_8 Q=n1908
Xclk_r_REG444_S1 DFFQX1TR $PINS D=n1590 CK=CTS_3 Q=n2056
Xclk_r_REG186_S1 DFFQX1TR $PINS D=n1345 CK=CTS_4 Q=n1785
Xclk_r_REG116_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out1_0_ CK=CTS_12
+ Q=n1722
Xclk_r_REG43_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<0> CK=CTS_9 Q=n1725
Xclk_r_REG511_S2 DFFQX1TR $PINS D=n2186 CK=CTS_8 Q=n1703
Xclk_r_REG423_S2 DFFQX1TR $PINS D=n2184 CK=CTS_8 Q=n1701
Xclk_r_REG491_S2 DFFQX1TR $PINS D=n2176 CK=CTS_3 Q=n1695
Xclk_r_REG447_S2 DFFQX1TR $PINS D=n2175 CK=CTS_3 Q=n1694
Xclk_r_REG403_S2 DFFQX1TR $PINS D=n2174 CK=CTS_3 Q=n1693
Xclk_r_REG359_S2 DFFQX1TR $PINS D=n2173 CK=CTS_3 Q=n1692
Xclk_r_REG492_S2 DFFQX1TR $PINS D=n2166 CK=CTS_6 Q=n1687
Xclk_r_REG448_S2 DFFQX1TR $PINS D=n2165 CK=CTS_6 Q=n1686
Xclk_r_REG316_S2 DFFQX1TR $PINS D=n2162 CK=CTS_6 Q=n1683
Xclk_r_REG272_S2 DFFQX1TR $PINS D=n2161 CK=CTS_6 Q=n1682
Xclk_r_REG184_S2 DFFQX1TR $PINS D=n2158 CK=CTS_6 Q=n1680
Xclk_r_REG473_S2 DFFQX1TR $PINS D=n2156 CK=CTS_12 Q=n1679
Xclk_r_REG341_S2 DFFQX1TR $PINS D=n2153 CK=CTS_12 Q=n1676
Xclk_r_REG297_S2 DFFQX1TR $PINS D=n2152 CK=CTS_2 Q=n1675
Xclk_r_REG209_S2 DFFQX1TR $PINS D=n2150 CK=CTS_2 Q=n1673
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG78_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n20 CK=CTS_11 Q=n1335
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG73_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n29 CK=CTS_11 Q=n1333
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG130_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<4> CK=CTS_11 Q=n1322
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG120_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n30 CK=CTS_2 Q=n1311
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG143_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<0> CK=CTS_2 Q=n1305
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG104_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n27 CK=CTS_2 Q=n1290
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG151_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<0> CK=CTS_2 Q=n1285
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG147_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<4> CK=CTS_2 Q=n1281
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG94_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n20 CK=CTS_2 Q=n1271
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG159_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<0> CK=CTS_11 Q=n1267
Xclk_r_REG29_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n31 CK=CTS_9
+ Q=n1715
Xclk_r_REG160_S1 DFFQX1TR $PINS D=n1376 CK=CTS_12 Q=n1819
Xclk_r_REG171_S1 DFFQX1TR $PINS D=n1365 CK=CTS_4 Q=n1807
Xclk_r_REG167_S1 DFFQX1TR $PINS D=n1361 CK=CTS_12 Q=n1803
Xclk_r_REG200_S1 DFFQX1TR $PINS D=n1359 CK=CTS_9 Q=n1801
Xclk_r_REG486_S1 DFFQX1TR $PINS D=n1624 CK=CTS_4 Q=n2094
Xclk_r_REG484_S1 DFFQX1TR $PINS D=n1622 CK=CTS_7 Q=n2092
Xclk_r_REG483_S1 DFFQX1TR $PINS D=n1621 CK=CTS_7 Q=n2091
Xclk_r_REG482_S1 DFFQX1TR $PINS D=n1620 CK=CTS_7 Q=n2090
Xclk_r_REG481_S1 DFFQX1TR $PINS D=n1619 CK=CTS_7 Q=n2089
Xclk_r_REG478_S1 DFFQX1TR $PINS D=n1616 CK=CTS_6 Q=n2086
Xclk_r_REG475_S1 DFFQX1TR $PINS D=n1613 CK=CTS_12 Q=n2083
Xclk_r_REG474_S1 DFFQX1TR $PINS D=n1612 CK=CTS_6 Q=n2082
Xclk_r_REG442_S1 DFFQX1TR $PINS D=n1588 CK=CTS_7 Q=n2054
Xclk_r_REG440_S1 DFFQX1TR $PINS D=n1586 CK=CTS_7 Q=n2052
Xclk_r_REG439_S1 DFFQX1TR $PINS D=n1585 CK=CTS_7 Q=n2051
Xclk_r_REG438_S1 DFFQX1TR $PINS D=n1584 CK=CTS_7 Q=n2050
Xclk_r_REG437_S1 DFFQX1TR $PINS D=n1583 CK=CTS_7 Q=n2049
Xclk_r_REG434_S1 DFFQX1TR $PINS D=n1580 CK=CTS_6 Q=n2046
Xclk_r_REG432_S1 DFFQX1TR $PINS D=n1578 CK=CTS_12 Q=n2044
Xclk_r_REG431_S1 DFFQX1TR $PINS D=n1577 CK=CTS_12 Q=n2043
Xclk_r_REG430_S1 DFFQX1TR $PINS D=n1576 CK=CTS_8 Q=n2042
Xclk_r_REG398_S1 DFFQX1TR $PINS D=n1552 CK=CTS_7 Q=n2014
Xclk_r_REG396_S1 DFFQX1TR $PINS D=n1550 CK=CTS_7 Q=n2012
Xclk_r_REG395_S1 DFFQX1TR $PINS D=n1549 CK=CTS_7 Q=n2011
Xclk_r_REG394_S1 DFFQX1TR $PINS D=n1548 CK=CTS_7 Q=n2010
Xclk_r_REG393_S1 DFFQX1TR $PINS D=n1547 CK=CTS_7 Q=n2009
Xclk_r_REG390_S1 DFFQX1TR $PINS D=n1544 CK=CTS_6 Q=n2006
Xclk_r_REG388_S1 DFFQX1TR $PINS D=n1542 CK=CTS_12 Q=n2004
Xclk_r_REG387_S1 DFFQX1TR $PINS D=n1541 CK=CTS_12 Q=n2003
Xclk_r_REG386_S1 DFFQX1TR $PINS D=n1540 CK=CTS_12 Q=n2002
Xclk_r_REG354_S1 DFFQX1TR $PINS D=n1516 CK=CTS_4 Q=n1974
Xclk_r_REG351_S1 DFFQX1TR $PINS D=n1513 CK=CTS_7 Q=n1971
Xclk_r_REG350_S1 DFFQX1TR $PINS D=n1512 CK=CTS_7 Q=n1970
Xclk_r_REG349_S1 DFFQX1TR $PINS D=n1511 CK=CTS_7 Q=n1969
Xclk_r_REG346_S1 DFFQX1TR $PINS D=n1508 CK=CTS_6 Q=n1966
Xclk_r_REG344_S1 DFFQX1TR $PINS D=n1506 CK=CTS_6 Q=n1964
Xclk_r_REG343_S1 DFFQX1TR $PINS D=n1505 CK=CTS_6 Q=n1963
Xclk_r_REG342_S1 DFFQX1TR $PINS D=n1504 CK=CTS_8 Q=n1962
Xclk_r_REG310_S1 DFFQX1TR $PINS D=n1480 CK=CTS_7 Q=n1934
Xclk_r_REG503_S1 DFFQX1TR $PINS D=n1606 CK=CTS_3 Q=n2074
Xclk_r_REG459_S1 DFFQX1TR $PINS D=n1570 CK=CTS_3 Q=n2034
Xclk_r_REG506_S1 DFFQX1TR $PINS D=n1609 CK=CTS_8 Q=n2077
Xclk_r_REG418_S1 DFFQX1TR $PINS D=n1537 CK=CTS_7 Q=n1997
Xclk_r_REG374_S1 DFFQX1TR $PINS D=n1501 CK=CTS_8 Q=n1957
Xclk_r_REG330_S1 DFFQX1TR $PINS D=n1465 CK=CTS_8 Q=n1917
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG117_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n7 CK=CTS_2 Q=n1315
Xclk_r_REG24_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n32 CK=CTS_9
+ Q=n1716
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG79_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n2 CK=CTS_11 Q=n1328
Xclk_r_REG468_S1 DFFQX1TR $PINS D=n1628 CK=CTS_6 Q=n2099
Xclk_r_REG479_S1 DFFQX1TR $PINS D=n1617 CK=CTS_4 Q=n2087
Xclk_r_REG424_S1 DFFQX1TR $PINS D=n1592 CK=CTS_12 Q=n2059
Xclk_r_REG435_S1 DFFQX1TR $PINS D=n1581 CK=CTS_4 Q=n2047
Xclk_r_REG380_S1 DFFQX1TR $PINS D=n1556 CK=CTS_2 Q=n2019
Xclk_r_REG391_S1 DFFQX1TR $PINS D=n1545 CK=CTS_4 Q=n2007
Xclk_r_REG336_S1 DFFQX1TR $PINS D=n1520 CK=CTS_6 Q=n1979
Xclk_r_REG347_S1 DFFQX1TR $PINS D=n1509 CK=CTS_4 Q=n1967
Xclk_r_REG292_S1 DFFQX1TR $PINS D=n1484 CK=CTS_2 Q=n1939
Xclk_r_REG303_S1 DFFQX1TR $PINS D=n1473 CK=CTS_4 Q=n1927
Xclk_r_REG248_S1 DFFQX1TR $PINS D=n1448 CK=CTS_12 Q=n1899
Xclk_r_REG259_S1 DFFQX1TR $PINS D=n1437 CK=CTS_4 Q=n1887
Xclk_r_REG502_S1 DFFQX1TR $PINS D=n1605 CK=CTS_7 Q=n2073
Xclk_r_REG501_S1 DFFQX1TR $PINS D=n1604 CK=CTS_7 Q=n2072
Xclk_r_REG499_S1 DFFQX1TR $PINS D=n1602 CK=CTS_8 Q=n2070
Xclk_r_REG498_S1 DFFQX1TR $PINS D=n1601 CK=CTS_8 Q=n2069
Xclk_r_REG497_S1 DFFQX1TR $PINS D=n1600 CK=CTS_8 Q=n2068
Xclk_r_REG458_S1 DFFQX1TR $PINS D=n1569 CK=CTS_7 Q=n2033
Xclk_r_REG457_S1 DFFQX1TR $PINS D=n1568 CK=CTS_7 Q=n2032
Xclk_r_REG455_S1 DFFQX1TR $PINS D=n1566 CK=CTS_8 Q=n2030
Xclk_r_REG454_S1 DFFQX1TR $PINS D=n1565 CK=CTS_8 Q=n2029
Xclk_r_REG414_S1 DFFQX1TR $PINS D=n1533 CK=CTS_7 Q=n1993
Xclk_r_REG413_S1 DFFQX1TR $PINS D=n1532 CK=CTS_7 Q=n1992
Xclk_r_REG411_S1 DFFQX1TR $PINS D=n1530 CK=CTS_8 Q=n1990
Xclk_r_REG410_S1 DFFQX1TR $PINS D=n1529 CK=CTS_8 Q=n1989
Xclk_r_REG409_S1 DFFQX1TR $PINS D=n1528 CK=CTS_8 Q=n1988
Xclk_r_REG370_S1 DFFQX1TR $PINS D=n1497 CK=CTS_7 Q=n1953
Xclk_r_REG369_S1 DFFQX1TR $PINS D=n1496 CK=CTS_7 Q=n1952
Xclk_r_REG367_S1 DFFQX1TR $PINS D=n1494 CK=CTS_8 Q=n1950
Xclk_r_REG366_S1 DFFQX1TR $PINS D=n1493 CK=CTS_8 Q=n1949
Xclk_r_REG365_S1 DFFQX1TR $PINS D=n1492 CK=CTS_8 Q=n1948
Xclk_r_REG326_S1 DFFQX1TR $PINS D=n1461 CK=CTS_7 Q=n1913
Xclk_r_REG325_S1 DFFQX1TR $PINS D=n1460 CK=CTS_7 Q=n1912
Xclk_r_REG323_S1 DFFQX1TR $PINS D=n1458 CK=CTS_8 Q=n1910
Xclk_r_REG322_S1 DFFQX1TR $PINS D=n1457 CK=CTS_8 Q=n1909
Xclk_r_REG282_S1 DFFQX1TR $PINS D=n1425 CK=CTS_7 Q=n1873
Xclk_r_REG281_S1 DFFQX1TR $PINS D=n1424 CK=CTS_7 Q=n1872
Xclk_r_REG279_S1 DFFQX1TR $PINS D=n1422 CK=CTS_8 Q=n1870
Xclk_r_REG278_S1 DFFQX1TR $PINS D=n1421 CK=CTS_8 Q=n1869
Xclk_r_REG277_S1 DFFQX1TR $PINS D=n1420 CK=CTS_7 Q=n1868
Xclk_r_REG238_S1 DFFQX1TR $PINS D=n1389 CK=CTS_7 Q=n1833
Xclk_r_REG237_S1 DFFQX1TR $PINS D=n1388 CK=CTS_7 Q=n1832
Xclk_r_REG235_S1 DFFQX1TR $PINS D=n1386 CK=CTS_8 Q=n1830
Xclk_r_REG505_S1 DFFQX1TR $PINS D=n1608 CK=CTS_8 Q=n2076
Xclk_r_REG461_S1 DFFQX1TR $PINS D=n1572 CK=CTS_8 Q=n2036
Xclk_r_REG488_S1 DFFQX1TR $PINS D=n1626 CK=CTS_3 Q=n2096
Xclk_r_REG495_S1 DFFQX1TR $PINS D=n1598 CK=CTS_4 Q=n2066
Xclk_r_REG494_S1 DFFQX1TR $PINS D=n1597 CK=CTS_4 Q=n2065
Xclk_r_REG451_S1 DFFQX1TR $PINS D=n1562 CK=CTS_4 Q=n2026
Xclk_r_REG450_S1 DFFQX1TR $PINS D=n1561 CK=CTS_4 Q=n2025
Xclk_r_REG400_S1 DFFQX1TR $PINS D=n1554 CK=CTS_4 Q=n2016
Xclk_r_REG407_S1 DFFQX1TR $PINS D=n1526 CK=CTS_4 Q=n1986
Xclk_r_REG406_S1 DFFQX1TR $PINS D=n1525 CK=CTS_4 Q=n1985
Xclk_r_REG356_S1 DFFQX1TR $PINS D=n1518 CK=CTS_3 Q=n1976
Xclk_r_REG363_S1 DFFQX1TR $PINS D=n1490 CK=CTS_4 Q=n1946
Xclk_r_REG362_S1 DFFQX1TR $PINS D=n1489 CK=CTS_4 Q=n1945
Xclk_r_REG312_S1 DFFQX1TR $PINS D=n1482 CK=CTS_3 Q=n1936
Xclk_r_REG319_S1 DFFQX1TR $PINS D=n1454 CK=CTS_4 Q=n1906
Xclk_r_REG318_S1 DFFQX1TR $PINS D=n1453 CK=CTS_4 Q=n1905
Xclk_r_REG268_S1 DFFQX1TR $PINS D=n1446 CK=CTS_4 Q=n1896
Xclk_r_REG275_S1 DFFQX1TR $PINS D=n1418 CK=CTS_4 Q=n1866
Xclk_r_REG187_S1 DFFQX1TR $PINS D=n1346 CK=CTS_4 Q=n1786
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG111_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n13 CK=CTS_2 Q=n1295
Xclk_r_REG81_S1 DFFQX1TR $PINS D=FE_OFN143_reset CK=CTS_11 Q=n2107
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG118_S2 DFFQX1TR $PINS D=n3 CK=CTS_2
+ Q=n1310
Xclk_r_REG500_S1 DFFQX1TR $PINS D=n1603 CK=CTS_8 Q=n2071
Xclk_r_REG456_S1 DFFQX1TR $PINS D=n1567 CK=CTS_8 Q=n2031
Xclk_r_REG412_S1 DFFQX1TR $PINS D=n1531 CK=CTS_8 Q=n1991
Xclk_r_REG368_S1 DFFQX1TR $PINS D=n1495 CK=CTS_8 Q=n1951
Xclk_r_REG324_S1 DFFQX1TR $PINS D=n1459 CK=CTS_8 Q=n1911
Xclk_r_REG280_S1 DFFQX1TR $PINS D=n1423 CK=CTS_8 Q=n1871
Xclk_r_REG236_S1 DFFQX1TR $PINS D=n1387 CK=CTS_8 Q=n1831
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG145_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<6> CK=CTS_2 Q=n1279
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG157_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<2> CK=CTS_11 Q=n1265
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG102_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n29 CK=CTS_2 Q=n1291
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG71_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n7 CK=CTS_11 Q=n1336
Xclk_r_REG508_S1 DFFQX1TR $PINS D=n1611 CK=CTS_12 Q=n2081
Xclk_r_REG464_S1 DFFQX1TR $PINS D=n1575 CK=CTS_12 Q=n2041
Xclk_r_REG420_S1 DFFQX1TR $PINS D=n1539 CK=CTS_12 Q=n2001
Xclk_r_REG376_S1 DFFQX1TR $PINS D=n1503 CK=CTS_9 Q=n1961
Xclk_r_REG332_S1 DFFQX1TR $PINS D=n1467 CK=CTS_12 Q=n1921
Xclk_r_REG288_S1 DFFQX1TR $PINS D=n1431 CK=CTS_9 Q=n1881
Xclk_r_REG244_S1 DFFQX1TR $PINS D=n1395 CK=CTS_8 Q=n1841
Xclk_r_REG550_S1 DFFQX1TR $PINS D=n1660 CK=CTS_9 Q=n2133
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG96_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_33_n2 CK=CTS_2 Q=n1269
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG121_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n25 CK=CTS_2 Q=n1316
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG125_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n20 CK=CTS_2 Q=n1308
Xclk_r_REG115_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out_int_4_
+ CK=CTS_2 Q=n1775
Xclk_r_REG333_S2 DFFQX1TR $PINS D=n1921 CK=CTS_9 Q=n1920
Xclk_r_REG314_S2 DFFQX1TR $PINS D=n1938 CK=CTS_6 Q=n1937
Xclk_r_REG296_S2 DFFQX1TR $PINS D=n1943 CK=CTS_12 Q=n1942
Xclk_r_REG490_S2 DFFQX1TR $PINS D=n2098 CK=CTS_6 Q=n2097
Xclk_r_REG472_S2 DFFQX1TR $PINS D=n2103 CK=CTS_12 Q=n2102
Xclk_r_REG428_S2 DFFQX1TR $PINS D=n2063 CK=CTS_9 Q=n2062
Xclk_r_REG421_S2 DFFQX1TR $PINS D=n2001 CK=CTS_9 Q=n2000
Xclk_r_REG510_S2 DFFQX1TR $PINS D=n2079 CK=CTS_3 Q=n2078
Xclk_r_REG290_S2 DFFQX1TR $PINS D=n1879 CK=CTS_3 Q=n1878
Xclk_r_REG378_S2 DFFQX1TR $PINS D=n1959 CK=CTS_3 Q=n1958
Xclk_r_REG422_S2 DFFQX1TR $PINS D=n1999 CK=CTS_3 Q=n1998
Xclk_r_REG202_S2 DFFQX1TR $PINS D=n1799 CK=CTS_3 Q=n1798
Xclk_r_REG466_S2 DFFQX1TR $PINS D=n2039 CK=CTS_3 Q=n2038
Xclk_r_REG358_S2 DFFQX1TR $PINS D=n1978 CK=CTS_2 Q=n1977
Xclk_r_REG402_S2 DFFQX1TR $PINS D=n2018 CK=CTS_2 Q=n2017
Xclk_r_REG446_S2 DFFQX1TR $PINS D=n2058 CK=CTS_6 Q=n2057
Xclk_r_REG384_S2 DFFQX1TR $PINS D=n2023 CK=CTS_12 Q=n2022
Xclk_r_REG340_S2 DFFQX1TR $PINS D=n1983 CK=CTS_12 Q=n1982
Xclk_r_REG182_S2 DFFQX1TR $PINS D=n1818 CK=CTS_6 Q=n1817
Xclk_r_REG13_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<5> CK=CTS_9 Q=n1730
Xclk_r_REG246_S2 DFFQX1TR $PINS D=n1839 CK=CTS_3 Q=n1838
Xclk_r_REG33_S3 DFFQX1TR $PINS D=n1668 CK=CTS_9 Q=n2141
Xclk_r_REG45_S3 DFFQX1TR $PINS D=n1340 CK=CTS_9 Q=n1748
Xclk_r_REG180_S1 DFFQX1TR $PINS D=n1374 CK=CTS_4 Q=n1816
Xclk_r_REG197_S1 DFFQX1TR $PINS D=n1356 CK=CTS_8 Q=n1796
Xclk_r_REG470_S1 DFFQX1TR $PINS D=n1630 CK=CTS_12 Q=n2101
Xclk_r_REG441_S1 DFFQX1TR $PINS D=n1587 CK=CTS_7 Q=n2053
Xclk_r_REG389_S1 DFFQX1TR $PINS D=n1543 CK=CTS_6 Q=n2005
Xclk_r_REG294_S1 DFFQX1TR $PINS D=n1486 CK=CTS_12 Q=n1941
Xclk_r_REG80_S1 DFFQX1TR $PINS D=n1634 CK=CTS_12 Q=n2106
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG149_S1 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<2> CK=CTS_2 Q=n1283
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG129_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<5> CK=CTS_11 Q=n1321
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG109_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_30_n20 CK=CTS_2 Q=n1293
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG110_S2 DFFQX1TR $PINS D=n1297
+ CK=CTS_2 Q=n1286
Xclk_r_REG183_S2 DFFQX1TR $PINS D=n2168 CK=CTS_3 Q=n1688
Xclk_r_REG271_S2 DFFQX1TR $PINS D=n2171 CK=CTS_3 Q=n1690
Xclk_r_REG227_S2 DFFQX1TR $PINS D=n2170 CK=CTS_3 Q=n1689
Xclk_r_REG15_S3 DFFQX1TR $PINS D=n1670 CK=CTS_9 Q=n2143
Xclk_r_REG334_S2 DFFQX1TR $PINS D=n1919 CK=CTS_3 Q=n1918
Xclk_r_REG208_S2 DFFQX1TR $PINS D=n1863 CK=CTS_12 Q=n1862
Xclk_r_REG19_S2 DFFQX1TR $PINS D=PE_top0_OUT_ADD<4> CK=CTS_9 Q=n1729
Xclk_r_REG9_S3 DFFQX1TR $PINS D=n1343 CK=CTS_9 Q=n1751
Xclk_r_REG226_S2 DFFQX1TR $PINS D=n1858 CK=CTS_2 Q=n1857
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG72_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n30 CK=CTS_11 Q=n1334
Xclk_r_REG23_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n27 CK=CTS_9
+ Q=n1713
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG74_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n5 CK=CTS_11 Q=n1332
Xclk_r_REG17_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n24 CK=CTS_9
+ Q=n1711
Xclk_r_REG6_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n18 CK=CTS_12
+ Q=n1710
Xclk_r_REG12_S1 DFFQX1TR $PINS D=PE_top0_DP_OP_17J1_122_4844_n25 CK=CTS_9
+ Q=n1712
Xclk_r_REG50_S2 DFFQX1TR $PINS D=PE_top0_ST_ADD<2> CK=CTS_11 Q=n1764
Xclk_r_REG56_S2 DFFQX1TR $PINS D=PE_top0_ST_ADD<1> CK=CTS_11 Q=n1765
Xclk_r_REG521_S1 DFFQX1TR $PINS D=n1645 CK=CTS_6 Q=n2118
Xclk_r_REG515_S1 DFFQX1TR $PINS D=n1639 CK=CTS_6 Q=n2112
Xclk_r_REG161_S1 DFFQX1TR $PINS D=n1377 CK=CTS_12 Q=n1820
Xclk_r_REG172_S1 DFFQX1TR $PINS D=n1366 CK=CTS_7 Q=n1808
Xclk_r_REG196_S1 DFFQX1TR $PINS D=n1355 CK=CTS_3 Q=n1795
Xclk_r_REG195_S1 DFFQX1TR $PINS D=n1354 CK=CTS_3 Q=n1794
Xclk_r_REG176_S1 DFFQX1TR $PINS D=n1370 CK=CTS_6 Q=n1812
Xclk_r_REG192_S1 DFFQX1TR $PINS D=n1351 CK=CTS_8 Q=n1791
Xclk_r_REG189_S1 DFFQX1TR $PINS D=n1348 CK=CTS_8 Q=n1788
Xclk_r_REG198_S1 DFFQX1TR $PINS D=n1357 CK=CTS_8 Q=n1797
Xclk_r_REG162_S1 DFFQX1TR $PINS D=n1378 CK=CTS_12 Q=n1821
Xclk_r_REG179_S1 DFFQX1TR $PINS D=n1373 CK=CTS_4 Q=n1815
Xclk_r_REG194_S1 DFFQX1TR $PINS D=n1353 CK=CTS_7 Q=n1793
Xclk_r_REG193_S1 DFFQX1TR $PINS D=n1352 CK=CTS_7 Q=n1792
Xclk_r_REG191_S1 DFFQX1TR $PINS D=n1350 CK=CTS_8 Q=n1790
Xclk_r_REG175_S1 DFFQX1TR $PINS D=n1369 CK=CTS_6 Q=n1811
Xclk_r_REG174_S1 DFFQX1TR $PINS D=n1368 CK=CTS_7 Q=n1810
Xclk_r_REG173_S1 DFFQX1TR $PINS D=n1367 CK=CTS_7 Q=n1809
Xclk_r_REG168_S1 DFFQX1TR $PINS D=n1362 CK=CTS_12 Q=n1804
Xclk_r_REG166_S1 DFFQX1TR $PINS D=n1360 CK=CTS_12 Q=n1802
Xclk_r_REG190_S1 DFFQX1TR $PINS D=n1349 CK=CTS_8 Q=n1789
Xclk_r_REG178_S1 DFFQX1TR $PINS D=n1372 CK=CTS_7 Q=n1814
Xclk_r_REG177_S1 DFFQX1TR $PINS D=n1371 CK=CTS_7 Q=n1813
Xclk_r_REG170_S1 DFFQX1TR $PINS D=n1364 CK=CTS_6 Q=n1806
Xclk_r_REG169_S1 DFFQX1TR $PINS D=n1363 CK=CTS_6 Q=n1805
Xclk_r_REG477_S1 DFFQX1TR $PINS D=n1615 CK=CTS_6 Q=n2085
Xclk_r_REG338_S1 DFFQX1TR $PINS D=n1522 CK=CTS_8 Q=n1981
Xclk_r_REG353_S1 DFFQX1TR $PINS D=n1515 CK=CTS_4 Q=n1973
Xclk_r_REG345_S1 DFFQX1TR $PINS D=n1507 CK=CTS_6 Q=n1965
Xclk_r_REG309_S1 DFFQX1TR $PINS D=n1479 CK=CTS_4 Q=n1933
Xclk_r_REG301_S1 DFFQX1TR $PINS D=n1471 CK=CTS_6 Q=n1925
Xclk_r_REG265_S1 DFFQX1TR $PINS D=n1443 CK=CTS_7 Q=n1893
Xclk_r_REG257_S1 DFFQX1TR $PINS D=n1435 CK=CTS_6 Q=n1885
Xclk_r_REG250_S1 DFFQX1TR $PINS D=n1450 CK=CTS_12 Q=n1901
Xclk_r_REG221_S1 DFFQX1TR $PINS D=n1407 CK=CTS_6 Q=n1853
Xclk_r_REG213_S1 DFFQX1TR $PINS D=n1399 CK=CTS_6 Q=n1845
Xclk_r_REG206_S1 DFFQX1TR $PINS D=n1414 CK=CTS_8 Q=n1861
Xclk_r_REG382_S1 DFFQX1TR $PINS D=n1558 CK=CTS_12 Q=n2021
Xclk_r_REG485_S1 DFFQX1TR $PINS D=n1623 CK=CTS_4 Q=n2093
Xclk_r_REG426_S1 DFFQX1TR $PINS D=n1594 CK=CTS_8 Q=n2061
Xclk_r_REG433_S1 DFFQX1TR $PINS D=n1579 CK=CTS_6 Q=n2045
Xclk_r_REG397_S1 DFFQX1TR $PINS D=n1551 CK=CTS_7 Q=n2013
XU14 NAND2X1TR $PINS A=n641 B=n640 Y=PE_top0_DP_OP_17J1_122_4844_n32
XU15 AO22X1TR $PINS A0=n911 A1=FE_OFN39_n941 B0=n966 B1=n1929 Y=n1475
XU16 AO22X1TR $PINS A0=n911 A1=FE_OFN57_n938 B0=n966 B1=n1849 Y=n1403
XU17 INVX2TR $PINS A=n697 Y=PE_top0_buff_mult_arr0_mult_x_33_n31
XU18 AO22X1TR $PINS A0=n908 A1=FE_OFN35_n938 B0=n1007 B1=n1847 Y=n1401
XU19 INVX2TR $PINS A=n671 Y=PE_top0_buff_mult_arr0_mult_x_24_n31
XU20 AO22X1TR $PINS A0=FE_OFN130_n928 A1=FE_OFN35_n938 B0=n950 B1=n1859 Y=n1412
XU21 AO22X1TR $PINS A0=FE_OFN123_n902 A1=FE_OFN29_FE_DBTN3_reset B0=n960
+ B1=n2111 Y=n1638
XU33 NAND2X1TR $PINS A=n145 B=n144 Y=n268
XU34 NOR2X1TR $PINS A=FE_OFN6_reset B=pe_in_pk_rdb_addr__3_ Y=n1048
XU35 NAND2X1TR $PINS A=n637 B=n636 Y=n638
XU45 INVX2TR $PINS A=n808 Y=n813
XU47 XOR3X2TR $PINS A=n485 B=n484 C=n483 Y=n791
XU50 OAI21X2TR $PINS A0=n923 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n905
XU51 OR2X2TR $PINS A=n577 B=n576 Y=n812
XU53 OAI21X2TR $PINS A0=n917 A1=n874 B0=FE_OFN30_FE_DBTN3_reset Y=n878
XU54 OR2X4TR $PINS A=n357 B=n356 Y=n363
XU55 NAND2X2TR $PINS A=n653 B=n652 Y=n667
XU74 OR2X4TR $PINS A=n254 B=n659 Y=n10
XU95 INVX2TR $PINS A=n1064 Y=n563
XU96 NAND2X1TR $PINS A=n543 B=n542 Y=n1055
XU97 OAI21X1TR $PINS A0=n893 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n930
XU99 OAI22X1TR $PINS A0=n520 A1=n494 B0=n518 B1=n491 Y=n503
XU100 OAI21X1TR $PINS A0=n934 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n935
XU101 OAI21X1TR $PINS A0=n879 A1=n917 B0=FE_OFN146_reset Y=n884
XU102 OAI21X2TR $PINS A0=n913 A1=n907 B0=FE_OFN1_reset Y=n914
XU103 OAI21X2TR $PINS A0=n923 A1=n874 B0=FE_OFN31_FE_DBTN3_reset Y=n924
XU106 OAI21X1TR $PINS A0=n915 A1=n907 B0=FE_OFN1_reset Y=n916
XU107 OAI21X1TR $PINS A0=n921 A1=n907 B0=FE_OFN1_reset Y=n919
XU108 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__2_ B=FE_OFN6_reset Y=n945
XU109 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__1_ B=FE_OFN6_reset Y=n946
XU110 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__0_ B=FE_OFN6_reset Y=n947
XU111 XOR3X2TR $PINS A=n500 B=n499 C=n498 Y=n501
XU112 NOR2X1TR $PINS A=n252 B=n251 Y=n834
XU113 OAI21X1TR $PINS A0=n913 A1=n874 B0=FE_OFN30_FE_DBTN3_reset Y=n876
XU114 OAI21X1TR $PINS A0=n893 A1=n907 B0=FE_OFN30_FE_DBTN3_reset Y=n909
XU115 OAI21X1TR $PINS A0=n893 A1=n874 B0=FE_OFN31_FE_DBTN3_reset Y=n894
XU116 OAI21X1TR $PINS A0=n879 A1=n910 B0=FE_OFN146_reset Y=n880
XU117 OAI21X1TR $PINS A0=n910 A1=n874 B0=FE_OFN30_FE_DBTN3_reset Y=n875
XU118 OAI21X1TR $PINS A0=n879 A1=n921 B0=FE_OFN146_reset Y=n886
XU119 OAI21X1TR $PINS A0=n879 A1=n923 B0=FE_OFN146_reset Y=n887
XU120 OAI21X1TR $PINS A0=n934 A1=n874 B0=FE_OFN31_FE_DBTN3_reset Y=n897
XU122 NAND4X1TR $PINS A=n6 B=FE_DBTN2_pe_in_pk_wrb_addr__0 C=n891 D=n934 Y=n893
XU123 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__0_ B=n6 C=n891 Y=n923
XU124 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=pe_in_pk_wrb_addr__1_
+ C=FE_DBTN2_pe_in_pk_wrb_addr__0 Y=n910
XU126 OR2X4TR $PINS A=n333 B=n332 Y=n1070
XU128 XOR2X1TR $PINS A=n1327 B=n71 Y=n72
XU129 NAND2X2TR $PINS A=pe_in_pk_wrb__0_ B=n906 Y=n879
XU130 INVX2TR $PINS A=n1059 Y=n248
XU132 OAI22X1TR $PINS A0=n685 A1=n496 B0=n199 B1=n495 Y=n499
XU134 NOR2BX1TR $PINS AN=n74 B=FE_DBTN0_n2107 Y=n75
XU135 XOR2X1TR $PINS A=n331 B=n299 Y=n117
XU136 NOR2BX1TR $PINS AN=n1772 B=FE_DBTN0_n2107 Y=n76
XU137 NAND2X2TR $PINS A=pe_in_pk_wrb__2_ B=n906 Y=n907
XU138 INVX2TR $PINS A=n226 Y=n251
XU139 NAND2X1TR $PINS A=n247 B=n246 Y=n1059
XU140 NAND2X1TR $PINS A=n236 B=n235 Y=n240
XU142 XNOR2X1TR $PINS A=n1298 B=n167 Y=n182
XU143 XNOR2X1TR $PINS A=n1260 B=n509 Y=n494
XU144 XOR2X1TR $PINS A=n1268 B=n83 Y=n84
XU145 XNOR2X1TR $PINS A=n1262 B=n492 Y=n511
XU146 CLKINVX2TR $PINS A=n490 Y=n520
XU147 XOR2X1TR $PINS A=n603 B=n380 Y=n381
XU148 OR2X2TR $PINS A=n405 B=n213 Y=n12
XU150 XNOR2X1TR $PINS A=n1264 B=n205 Y=n506
XU151 OAI22X1TR $PINS A0=n348 A1=n108 B0=n305 B1=n345 Y=n315
XU152 XOR2X1TR $PINS A=n167 B=n560 Y=n570
XU153 XNOR2X1TR $PINS A=n1325 B=n707 Y=n407
XU154 XOR2X1TR $PINS A=n555 B=n560 Y=n265
XU155 XOR2X1TR $PINS A=n165 B=n560 Y=n134
XU156 INVX2TR $PINS A=pe_in_pk_wrb_addr__3_ Y=n934
XU157 XNOR2X1TR $PINS A=n592 B=n591 Y=n593
XU158 AO22X4TR $PINS A0=n1708 A1=n1672 B0=n1782 B1=n1822 Y=n512
XU159 NAND2X1TR $PINS A=n584 B=n1314 Y=n380
XU161 NOR2BX1TR $PINS AN=n219 B=n713 Y=n229
XU162 INVX2TR $PINS A=n1280 Y=n5
XU164 XNOR2X1TR $PINS A=n1304 B=n167 Y=n557
XU165 AND2X2TR $PINS A=n489 B=n518 Y=n490
XU166 XNOR2X1TR $PINS A=n1300 B=n124 Y=n138
XU168 NAND2X4TR $PINS A=n198 B=n199 Y=n685
XU174 INVX2TR $PINS A=pe_in_pk_wrb_addr__2_ Y=n6
XU175 XOR2X1TR $PINS A=n1261 B=n1260 Y=n489
XU176 XOR2X1TR $PINS A=n1303 B=n1302 Y=n130
XU178 AO22X4TR $PINS A0=n1706 A1=n1693 B0=n1780 B1=n1998 Y=n167
XU179 NAND2X4TR $PINS A=n98 B=n97 Y=n99
XU180 XOR2X1TR $PINS A=n245 B=n390 Y=n231
XU184 CLKINVX2TR $PINS A=n1323 Y=n245
XU185 INVX4TR $PINS A=n1267 Y=n679
XU186 NOR2X2TR $PINS A=n1728 B=n2142 Y=n1029
XU190 NAND2X4TR $PINS A=n214 B=n213 Y=n215
XU196 XOR2X1TR $PINS A=n1322 B=n1321 Y=n218
XU199 XOR2X1TR $PINS A=n1324 B=n1323 Y=n214
XU201 AO21X1TR $PINS A0=n208 A1=FE_OCPN149_n206 B0=n497 Y=n498
XU202 XNOR2X1TR $PINS A=n107 B=n1282 Y=n477
XU203 XOR2X1TR $PINS A=n1338 B=n1336 Y=n90
XU204 NOR2X1TR $PINS A=n1715 B=n1717 Y=n840
XU205 NAND2X1TR $PINS A=n238 B=n237 Y=n239
XU206 CLKINVX1TR $PINS A=n737 Y=n272
XU207 OAI21X1TR $PINS A0=n921 A1=n874 B0=FE_OFN31_FE_DBTN3_reset Y=n922
XU208 NAND2X1TR $PINS A=n538 B=n537 Y=n854
XU210 INVX2TR $PINS A=n883 Y=n1013
XU211 AO22X1TR $PINS A0=n899 A1=FE_OFN40_n944 B0=n1005 B1=n1961 Y=n1503
XU212 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN35_n938 B0=n960 B1=n1843
+ Y=n1397
XU213 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN37_n940 B0=n960 B1=n1883
+ Y=n1433
XU214 AO22X1TR $PINS A0=n911 A1=FE_OFN37_n940 B0=n966 B1=n1889 Y=n1439
XU215 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN38_n941 B0=n960 B1=n1923
+ Y=n1469
XU216 AO22X1TR $PINS A0=FE_OFN128_n928 A1=FE_OFN29_FE_DBTN3_reset B0=n950
+ B1=n2105 Y=n1633
XU217 AO22X1TR $PINS A0=n911 A1=FE_OFN1_reset B0=n966 B1=n2114 Y=n1641
XU218 AO22X1TR $PINS A0=n908 A1=FE_OFN30_FE_DBTN3_reset B0=n1007 B1=n2134
+ Y=n1661
XU219 OAI22X2TR $PINS A0=n409 A1=n224 B0=n395 B1=n408 Y=n2
XU228 NOR2X1TR $PINS A=n797 B=n796 Y=n3
XU229 XNOR2X2TR $PINS A=n509 B=n1266 Y=n4
XU233 NOR2X2TR $PINS A=n769 B=PE_top0_buff_mult_arr0_mult_x_33_n29 Y=n696
XU234 AND2X2TR $PINS A=n1074 B=FE_OFN144_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out1_0_
XU237 INVX2TR $PINS A=n878 Y=n990
XU240 AND2X2TR $PINS A=n75 B=FE_OFN144_reset Y=n96
XU244 NAND3BX1TR $PINS AN=n1766 B=n744 C=FE_OFN143_reset Y=n871
XU246 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__1_ B=n6
+ C=FE_DBTN2_pe_in_pk_wrb_addr__0 Y=n921
XU248 AND2X1TR $PINS A=n1767 B=n1733 Y=pk_out_data__0_
XU249 AND2X1TR $PINS A=n1767 B=n1735 Y=pk_out_data__1_
XU250 AND2X1TR $PINS A=n1767 B=n1737 Y=pk_out_data__2_
XU251 AND2X1TR $PINS A=n1767 B=n1739 Y=pk_out_data__3_
XU252 AND2X1TR $PINS A=n1767 B=n1741 Y=pk_out_data__4_
XU253 AND2X1TR $PINS A=n1767 B=n1745 Y=pk_out_data__6_
XU254 AND2X1TR $PINS A=n1767 B=n1743 Y=pk_out_data__5_
XU255 AND2X2TR $PINS A=FE_OCPN231_pe_in_pk_rdb_addr__1 B=pe_in_pk_rdb_addr__0_
+ Y=n58
XU257 INVX1TR $PINS A=n834 Y=n835
XU258 AND2X2TR $PINS A=n1079 B=FE_OFN143_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out1_0_
XU259 INVX2TR $PINS A=n13 Y=n830
XU266 ADDFHX2TR $PINS A=n229 B=n228 CI=n227 S=n250 CO=n226
XU267 AND2X2TR $PINS A=n274 B=FE_OFN143_reset Y=pe_out_pk_data__6_
XU271 AND2X2TR $PINS A=n1023 B=FE_OFN26_FE_DBTN3_reset Y=pe_out_pk_data__2_
XU272 INVX1TR $PINS A=n1055 Y=n544
XU276 XNOR2X1TR $PINS A=n626 B=n625 Y=n628
XU277 NOR2BX1TR $PINS AN=n200 B=n518 Y=n678
XU279 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__6_ B=FE_OFN6_reset Y=n938
XU281 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__3_ B=FE_OFN6_reset Y=n944
XU282 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__5_ B=FE_OFN6_reset Y=n940
XU283 NOR2BX1TR $PINS AN=pe_in_pk_wrb_data__4_ B=FE_OFN6_reset Y=n941
XU284 INVX1TR $PINS A=n863 Y=n865
XU285 INVX1TR $PINS A=n1097 Y=n1098
XU286 INVX1TR $PINS A=n1096 Y=n1099
XU287 INVX1TR $PINS A=n1704 Y=n1084
XU288 INVX1TR $PINS A=n1717 Y=n1081
XU289 XOR2X2TR $PINS A=n1318 B=n1315 Y=n74
XU290 INVX2TR $PINS A=pe_in_pk_rdb_addr__0_ Y=n63
XU291 INVX2TR $PINS A=pe_in_pk_rdb_addr__1_ Y=n61
XU292 INVX2TR $PINS A=pe_in_pk_rdb_addr__2_ Y=n62
XU293 CLKXOR2X4TR $PINS A=n1324 B=FE_DBTN1_n1325 Y=n213
XU296 XOR2X2TR $PINS A=n222 B=n701 Y=n714
XU297 OAI22X2TR $PINS A0=n348 A1=n347 B0=n346 B1=n345 Y=n783
XU298 XOR2X1TR $PINS A=n768 B=n9
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<4>
XU299 AND2X2TR $PINS A=n767 B=n766 Y=n9
XU300 OAI21X1TR $PINS A0=n927 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n928
XU301 OAI21X1TR $PINS A0=n927 A1=n907 B0=FE_OFN30_FE_DBTN3_reset Y=n908
XU302 OAI21X1TR $PINS A0=n927 A1=n879 B0=FE_OFN146_reset Y=n896
XU303 OAI21X1TR $PINS A0=n927 A1=n874 B0=FE_OFN31_FE_DBTN3_reset Y=n890
XU304 INVX2TR $PINS A=n769 Y=n771
XU305 OR2X4TR $PINS A=n434 B=n433 Y=n767
XU306 NAND2X2TR $PINS A=n10 B=n253 Y=n671
XU307 NAND2X2TR $PINS A=n836 B=n831 Y=n254
XU308 AOI21X1TR $PINS A0=n671 A1=n670 B0=n669
+ Y=PE_top0_buff_mult_arr0_mult_x_24_n1
XU309 NOR2BX1TR $PINS AN=n124 B=n183 Y=n143
XU310 NOR2BX1TR $PINS AN=n583 B=FE_DBTN3_reset Y=n623
XU311 AND2X2TR $PINS A=n594 B=FE_OFN144_reset Y=n634
XU313 OR2X2TR $PINS A=n215 B=n399 Y=n11
XU314 NAND2X2TR $PINS A=n11 B=n12 Y=n400
XU315 NOR2X4TR $PINS A=n653 B=n652 Y=n668
XU316 XOR2X1TR $PINS A=n245 B=n699 Y=n399
XU317 XOR2X1TR $PINS A=n5 B=n299 Y=n475
XU318 NAND2X1TR $PINS A=n831 B=n830 Y=n832
XU319 XNOR2X2TR $PINS A=n1319 B=n219 Y=n391
XU321 NOR2BX1TR $PINS AN=n286 B=n1777 Y=n287
XU324 OAI22X2TR $PINS A0=n215 A1=n396 B0=n213 B1=n399 Y=n649
XU325 OAI22X4TR $PINS A0=n682 A1=n209 B0=n681 B1=n679 Y=n677
XU326 XNOR2X2TR $PINS A=n1266 B=n205 Y=n681
XU327 XNOR2X2TR $PINS A=n1284 B=n321 Y=n14
XU328 NOR2X1TR $PINS A=n838 B=n837 Y=PE_top0_buff_mult_arr0_mult_x_24_n19
XU329 XNOR2X2TR $PINS A=n611 B=n15 Y=n373
XU330 AND2X2TR $PINS A=n595 B=n1288 Y=n15
XU331 XNOR2X2TR $PINS A=n1325 B=n710 Y=n398
XU332 NOR2BX1TR $PINS AN=n629 B=FE_OFN148_reset Y=n850
XU333 OAI22X1TR $PINS A0=n99 A1=n301 B0=n97 B1=n117 Y=n302
XU334 NAND2X1TR $PINS A=n819 B=n818 Y=PE_top0_buff_mult_arr0_mult_x_27_n23
XU335 XNOR3X2TR $PINS A=n179 B=n178 C=n16 Y=n195
XU336 XNOR3X2TR $PINS A=n177 B=n176 C=n175 Y=n16
XU337 AO22X1TR $PINS A0=n871 A1=n870 B0=n745 B1=n1751 Y=n1343
XU338 NAND2X2TR $PINS A=n527 B=n526 Y=PE_top0_buff_mult_arr0_mult_x_33_n2
XU339 OA22X2TR $PINS A0=n180 A1=n573 B0=n174 B1=n129 Y=n17
XU340 XNOR2X1TR $PINS A=n833 B=n832
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out_int_4_
XU341 ADDFX2TR $PINS A=n385 B=n384 CI=n383 S=n386 CO=n851
XU342 NOR2BX1TR $PINS AN=n284 B=FE_OFN147_reset Y=n385
XU343 XOR2X1TR $PINS A=n424 B=n492 Y=n688
XU344 CLKINVX2TR $PINS A=n1264 Y=n424
XU345 XOR2X2TR $PINS A=FE_DBTN1_n1325 B=n701 Y=n395
XU346 XOR2X1TR $PINS A=n5 B=n321 Y=n116
XU347 OAI22X2TR $PINS A0=n702 A1=n56 B0=n714 B1=n713 Y=n728
XU348 AO21X2TR $PINS A0=n569 A1=n566 B0=n191 Y=n461
XU349 OA21XLTR $PINS A0=n1329 A1=n1331 B0=n1335 Y=n579
XU350 NAND2X1TR $PINS A=n624 B=n1335 Y=n625
XU351 NAND2X4TR $PINS A=n474 B=n103 Y=n476
XU352 NAND2X1TR $PINS A=n448 B=n445 Y=n443
XU353 NOR2BX1TR $PINS AN=n76 B=FE_DBTN3_reset Y=n95
XU354 OR2X2TR $PINS A=n247 B=n246 Y=n1060
XU356 XOR2X1TR $PINS A=n545 B=n855 Y=PE_top0_adder0_out_int2<1>
XU357 AOI21X1TR $PINS A0=n1056 A1=n1057 B0=n544 Y=n855
XU358 NOR2BX1TR $PINS AN=n92 B=FE_OFN148_reset Y=n261
XU359 NOR2BX2TR $PINS AN=n80 B=FE_OFN0_FE_DBTN0_n2107 Y=n81
XU360 NOR2X1TR $PINS A=n805 B=n804 Y=n806
XU362 CMPR22X2TR $PINS A=n411 B=n410 S=n644 CO=n729
XU363 NAND2X1TR $PINS A=n1725 B=n1748 Y=n860
XU364 XNOR2X1TR $PINS A=n1078 B=n1077 Y=n1079
XU365 NAND2X1TR $PINS A=n1076 B=n1075 Y=n1078
XU366 AO21X1TR $PINS A0=n573 A1=n129 B0=n174 Y=n175
XU367 AND2X2TR $PINS A=n743 B=FE_OFN143_reset Y=pe_out_pk_data__7_
XU368 XNOR2X1TR $PINS A=n742 B=n741 Y=n743
XU370 XNOR2X1TR $PINS A=n813 B=n578
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out_int_4_
XU371 OAI22X1TR $PINS A0=n520 A1=n519 B0=n518 B1=n517 Y=n674
XU372 OAI22X2TR $PINS A0=n685 A1=n204 B0=n199 B1=n203 Y=n211
XU373 OAI22X1TR $PINS A0=n190 A1=n189 B0=n132 B1=n188 Y=n462
XU374 XOR2X1TR $PINS A=n140 B=n170 Y=n172
XU376 OR2X4TR $PINS A=n525 B=n524 Y=n527
XU377 OR3X1TR $PINS A=FE_DBTN2_pe_in_pk_wrb_addr__0 B=n6
+ C=pe_in_pk_wrb_addr__1_ Y=n913
XU378 INVX2TR $PINS A=pe_in_pk_wrb_addr__1_ Y=n891
XU381 CLKINVX2TR $PINS A=n482 Y=n468
XU382 ADDFHX4TR $PINS A=n678 B=n677 CI=n676 S=n690 CO=n762
XU383 XNOR2X1TR $PINS A=n493 B=n1264 Y=n429
XU384 NAND2X1TR $PINS A=n805 B=n804 Y=n820
XU385 OAI22X2TR $PINS A0=n685 A1=n511 B0=n199 B1=n496 Y=n523
XU386 NAND2X1TR $PINS A=n735 B=n734 Y=PE_top0_buff_mult_arr0_mult_x_24_n2
XU388 XNOR2X4TR $PINS A=n1320 B=n1321 Y=n704
XU389 XNOR2X1TR $PINS A=n1266 B=n492 Y=n428
XU390 AO21X2TR $PINS A0=n348 A1=n345 B0=n115 Y=n121
XU391 OAI22X2TR $PINS A0=n348 A1=n300 B0=n115 B1=n345 Y=n304
XU392 XNOR2X1TR $PINS A=n1284 B=n107 Y=n115
XU393 OR2X2TR $PINS A=n459 B=n458 Y=n454
XU394 OAI22X1TR $PINS A0=n185 A1=n184 B0=n183 B1=n182 Y=n458
XU395 XNOR2X1TR $PINS A=n1262 B=n200 Y=n202
XU396 OAI21X1TR $PINS A0=n1714 A1=n1711 B0=n1712 Y=n1097
XU397 NOR2X1TR $PINS A=n814 B=n3 Y=PE_top0_buff_mult_arr0_mult_x_27_n24
XU398 OAI21X1TR $PINS A0=n814 A1=PE_top0_buff_mult_arr0_mult_x_27_n30 B0=n268
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n25
XU399 NOR2X6TR $PINS A=n145 B=n144 Y=n814
XU401 OAI22X2TR $PINS A0=n520 A1=n515 B0=n518 B1=n514 Y=n675
XU402 OAI22X1TR $PINS A0=n99 A1=n117 B0=n97 B1=n105 Y=n119
XU403 OAI22X1TR $PINS A0=n476 A1=n475 B0=n474 B1=n473 Y=n481
XU404 NAND2X4TR $PINS A=n252 B=n251 Y=n836
XU405 XNOR2X2TR $PINS A=n1319 B=n390 Y=n404
XU406 OAI22X2TR $PINS A0=n99 A1=n105 B0=n97 B1=n477 Y=n482
XU407 XNOR2X1TR $PINS A=n1323 B=n707 Y=n715
XU408 AO22X4TR $PINS A0=n1705 A1=n1696 B0=n1779 B1=n1800 Y=n707
XU409 XOR2X2TR $PINS A=n170 B=n560 Y=n180
XU410 XOR2X1TR $PINS A=n169 B=n560 Y=n174
XU411 XOR3X2TR $PINS A=n720 B=n719 C=n718 Y=n721
XU412 OAI22X1TR $PINS A0=n712 A1=n713 B0=n714 B1=n56 Y=n719
XU413 OAI22X1TR $PINS A0=n702 A1=n713 B0=n406 B1=n56 Y=n731
XU414 OAI22X4TR $PINS A0=n467 A1=n104 B0=n465 B1=n466 Y=n469
XU415 XNOR2X1TR $PINS A=n1278 B=n338 Y=n104
XU416 OAI21X1TR $PINS A0=n910 A1=n907 B0=FE_OFN1_reset Y=n911
XU417 XNOR2X2TR $PINS A=n1300 B=n166 Y=n173
XU418 NAND2BX1TR $PINS AN=n219 B=n1321 Y=n221
XU420 XNOR2X2TR $PINS A=n1304 B=n166 Y=n264
XU422 NOR2BX1TR $PINS AN=n89 B=FE_OFN148_reset Y=n278
XU423 NOR2BX1TR $PINS AN=n88 B=FE_OFN0_FE_DBTN0_n2107 Y=n89
XU424 XNOR2X2TR $PINS A=n1304 B=n170 Y=n131
XU425 INVX2TR $PINS A=n1322 Y=n216
XU426 OAI22X2TR $PINS A0=n190 A1=n173 B0=n132 B1=n172 Y=n176
XU427 AO22X2TR $PINS A0=n1707 A1=n1680 B0=n1781 B1=n1817 Y=n107
XU428 NOR2BX1TR $PINS AN=n73 B=FE_DBTN3_reset Y=n296
XU429 NOR2BX1TR $PINS AN=n72 B=FE_DBTN0_n2107 Y=n73
XU431 OAI22X1TR $PINS A0=n215 A1=n245 B0=n213 B1=n244 Y=n246
XU432 OAI22X1TR $PINS A0=n215 A1=n232 B0=n213 B1=n231 Y=n242
XU433 INVX2TR $PINS A=n776 Y=n54
XU434 ADDFHX2TR $PINS A=n780 B=n779 CI=n778 S=n793 CO=n776
XU435 XNOR2X1TR $PINS A=n1325 B=n699 Y=n224
XU437 NAND2X1TR $PINS A=n146 B=n268 Y=PE_top0_buff_mult_arr0_mult_x_27_n5
XU438 AOI21X1TR $PINS A0=n833 A1=n831 B0=n13
+ Y=PE_top0_buff_mult_arr0_mult_x_24_n39
XU439 NAND2X1TR $PINS A=n525 B=n524 Y=n526
XU440 XOR3X2TR $PINS A=n503 B=n502 C=n501 Y=n525
XU441 OAI22X2TR $PINS A0=n409 A1=n233 B0=n230 B1=n408 Y=n243
XU443 XNOR2X1TR $PINS A=n1282 B=n471 Y=n105
XU444 OAI22X1TR $PINS A0=n409 A1=n390 B0=n233 B1=n408 Y=n238
XU445 NAND2X2TR $PINS A=n1325 B=n408 Y=n409
XU446 AO22X2TR $PINS A0=n1706 A1=n1689 B0=n1838 B1=n1780 Y=n170
XU447 XOR3X2TR $PINS A=n723 B=n722 C=n721 Y=n733
XU448 XOR2X1TR $PINS A=n166 B=n560 Y=n181
XU449 AO22X2TR $PINS A0=n1706 A1=n1690 B0=n1780 B1=n1878 Y=n166
XU450 ADDFHX2TR $PINS A=n523 B=n521 CI=n522 S=n747 CO=n502
XU451 OAI22X1TR $PINS A0=n520 A1=n508 B0=n518 B1=n494 Y=n522
XU452 XNOR2X2TR $PINS A=n1304 B=n169 Y=n191
XU453 AO22X4TR $PINS A0=n1706 A1=n1688 B0=n1780 B1=n1798 Y=n169
XU454 XNOR2X1TR $PINS A=n1325 B=n403 Y=n233
XU455 XNOR2X1TR $PINS A=n1262 B=n507 Y=n201
XU456 XOR2X1TR $PINS A=n1281 B=n1280 Y=n103
XU457 INVX2TR $PINS A=n1707 Y=n53
XU458 OAI22X1TR $PINS A0=n569 A1=n125 B0=n557 B1=n566 Y=n551
XU459 NOR2BX1TR $PINS AN=n124 B=n129 Y=n550
XU460 NAND2BX1TR $PINS AN=n124 B=n1304 Y=n547
XU461 ADDHX1TR $PINS A=n575 B=n574 S=n562 CO=n576
XU462 OAI22X1TR $PINS A0=n573 A1=n559 B0=n129 B1=n572 Y=n574
XU463 XOR2X1TR $PINS A=n124 B=n560 Y=n559
XU464 XNOR2X1TR $PINS A=n1262 B=n493 Y=n51
XU465 INVX1TR $PINS A=n1262 Y=n204
XU466 NAND2BX1TR $PINS AN=n108 B=n1282 Y=n330
XU467 OAI22X1TR $PINS A0=n208 A1=n424 B0=FE_OCPN149_n206 B1=n423 Y=n425
XU468 NAND2BX1TR $PINS AN=n200 B=n1264 Y=n423
XU469 ADDHX1TR $PINS A=n432 B=n431 S=n426 CO=n433
XU470 XNOR2X1TR $PINS A=n1264 B=n200 Y=n422
XU471 ADDFHX1TR $PINS A=n440 B=n439 CI=n438 S=n434 CO=n442
XU472 OAI22X2TR $PINS A0=n215 A1=n225 B0=n396 B1=n213 Y=n664
XU473 NAND2X1TR $PINS A=n317 B=n316 Y=n318
XU474 NAND2X1TR $PINS A=n315 B=n314 Y=n319
XU475 INVX1TR $PINS A=n317 Y=n320
XU476 NAND2X1TR $PINS A=n414 B=n413 Y=n418
XU477 INVX1TR $PINS A=n416 Y=n419
XU478 CLKINVX1TR $PINS A=n1715 Y=n1085
XU479 NOR2X1TR $PINS A=n1713 B=n1711 Y=n1096
XU480 INVX1TR $PINS A=n1710 Y=n841
XU481 NOR2X1TR $PINS A=n1727 B=n2141 Y=n1027
XU482 XOR2X1TR $PINS A=n1337 B=n368 Y=n369
XU483 NAND2X1TR $PINS A=n1052 B=n1051 Y=PE_top0_DP_OP_17J1_122_4844_n28
XU484 AND2X1TR $PINS A=n846 B=n860 Y=n847
XU485 OR2X1TR $PINS A=n1725 B=n1748 Y=n846
XU486 CLKINVX2TR $PINS A=n1296 Y=n288
XU487 CLKINVX2TR $PINS A=n1317 Y=n281
XU489 INVX1TR $PINS A=n1278 Y=n111
XU490 XNOR2X1TR $PINS A=n1298 B=n124 Y=n126
XU491 NOR2BX1TR $PINS AN=n1774 B=FE_DBTN0_n2107 Y=n77
XU492 XNOR2X1TR $PINS A=n1266 B=n493 Y=n421
XU493 XNOR2X1TR $PINS A=n1284 B=n338 Y=n322
XU495 INVX1TR $PINS A=n1294 Y=n595
XU496 OR2X1TR $PINS A=n124 B=n560 Y=n46
XU497 XNOR2X1TR $PINS A=n1260 B=n493 Y=n508
XU498 OR2X1TR $PINS A=n1330 B=n1329 Y=n580
XU499 CMPR22X2TR $PINS A=n675 B=n674 S=n763 CO=n755
XU500 INVX1TR $PINS A=n1260 Y=n519
XU501 ADDFHX2TR $PINS A=n752 B=n751 CI=n750 S=n761 CO=n760
XU502 OAI22X1TR $PINS A0=n208 A1=n688 B0=FE_OCPN149_n206 B1=n686 Y=n750
XU503 XNOR2X2TR $PINS A=n1284 B=n463 Y=n347
XU504 XNOR2X1TR $PINS A=n299 B=n1284 Y=n346
XU505 OAI22X2TR $PINS A0=n476 A1=n306 B0=n474 B1=n116 Y=n303
XU506 XNOR2X1TR $PINS A=n1304 B=n165 Y=n567
XU507 XNOR2X2TR $PINS A=n1300 B=n555 Y=n189
XU508 INVX1TR $PINS A=n1319 Y=n393
XU509 NOR2BX1TR $PINS AN=n1775 B=FE_DBTN0_n2107 Y=n92
XU510 NAND2BX1TR $PINS AN=n219 B=n1325 Y=n234
XU511 NOR2BX1TR $PINS AN=n219 B=n213 Y=n237
XU512 NAND2BX1TR $PINS AN=n219 B=n1323 Y=n244
XU513 NAND2BX1TR $PINS AN=n108 B=n1284 Y=n313
XU514 NOR2BX1TR $PINS AN=n108 B=n97 Y=n316
XU515 NOR2BX1TR $PINS AN=n200 B=FE_OCPN149_n206 Y=n415
XU516 XNOR2X1TR $PINS A=n1323 B=n219 Y=n232
XU517 NAND2X1TR $PINS A=n549 B=n548 Y=n553
XU518 NAND2X1TR $PINS A=n551 B=n550 Y=n552
XU519 INVX1TR $PINS A=n551 Y=n554
XU520 INVX1TR $PINS A=n1711 Y=n1092
XU521 AO21X1TR $PINS A0=n215 A1=n213 B0=n715 Y=n718
XU522 OAI21X2TR $PINS A0=n934 A1=n879 B0=FE_OFN29_FE_DBTN3_reset Y=n899
XU523 NAND2X1TR $PINS A=n448 B=n767 Y=n451
XU524 ADDFHX2TR $PINS A=n749 B=n748 CI=n747 S=n773 CO=n524
XU526 OAI22X1TR $PINS A0=n201 A1=n685 B0=n199 B1=n51 Y=n692
XU527 OAI22X2TR $PINS A0=n428 A1=n682 B0=n209 B1=n679 Y=n437
XU529 NOR2X1TR $PINS A=n538 B=n537 Y=n856
XU530 INVX1TR $PINS A=n1029 Y=n1031
XU531 OR2X1TR $PINS A=n1730 B=n2143 Y=n1037
XU532 OR2X1TR $PINS A=n1732 B=n2144 Y=n740
XU534 OR2X4TR $PINS A=n250 B=n249 Y=n831
XU535 CLKINVX2TR $PINS A=n659 Y=n833
XU542 AND2X2TR $PINS A=pe_out_pk_data__6_ B=n744 Y=n870
XU543 NAND2X1TR $PINS A=n795 B=n794 Y=PE_top0_buff_mult_arr0_mult_x_27_n20
XU544 OAI21X1TR $PINS A0=n668 A1=PE_top0_buff_mult_arr0_mult_x_24_n30 B0=n667
+ Y=n669
XU545 AO22X1TR $PINS A0=n899 A1=FE_OFN26_FE_DBTN3_reset B0=n1005 B1=n2133
+ Y=n1660
XU546 AO22X1TR $PINS A0=n899 A1=FE_OFN57_n938 B0=n1005 B1=n1841 Y=n1395
XU547 AO22X1TR $PINS A0=n899 A1=FE_OFN37_n940 B0=n1005 B1=n1881 Y=n1431
XU548 AO22X1TR $PINS A0=n899 A1=FE_OFN38_n941 B0=n1005 B1=n1921 Y=n1467
XU549 AO22X1TR $PINS A0=n899 A1=FE_OFN43_n945 B0=n1005 B1=n2001 Y=n1539
XU550 AO22X1TR $PINS A0=n899 A1=FE_OFN44_n946 B0=n1005 B1=n2041 Y=n1575
XU551 AO22X1TR $PINS A0=n899 A1=FE_OFN61_n947 B0=n1005 B1=n2081 Y=n1611
XU552 NAND2X1TR $PINS A=n791 B=n790 Y=PE_top0_buff_mult_arr0_mult_x_30_n13
XU553 AO22X1TR $PINS A0=FE_OFN120_n908 A1=n940 B0=n1007 B1=n1887 Y=n1437
XU554 AO22X1TR $PINS A0=FE_OFN130_n928 A1=FE_OFN36_n940 B0=n950 B1=n1899
+ Y=n1448
XU555 AO22X1TR $PINS A0=FE_OFN121_n908 A1=FE_OFN39_n941 B0=n1007 B1=n1927
+ Y=n1473
XU556 AO22X1TR $PINS A0=FE_OFN130_n928 A1=FE_OFN38_n941 B0=n950 B1=n1939
+ Y=n1484
XU557 AO22X1TR $PINS A0=FE_OFN121_n908 A1=FE_OFN41_n944 B0=n1007 B1=n1967
+ Y=n1509
XU558 AO22X1TR $PINS A0=FE_OFN129_n928 A1=FE_OFN40_n944 B0=n950 B1=n1979
+ Y=n1520
XU559 AO22X1TR $PINS A0=FE_OFN121_n908 A1=FE_OFN42_n945 B0=n1007 B1=n2007
+ Y=n1545
XU560 AO22X1TR $PINS A0=FE_OFN130_n928 A1=FE_OFN43_n945 B0=n950 B1=n2019
+ Y=n1556
XU561 AO22X1TR $PINS A0=FE_OFN120_n908 A1=FE_OFN45_n946 B0=n1007 B1=n2047
+ Y=n1581
XU562 AO22X1TR $PINS A0=FE_OFN126_n928 A1=FE_OFN44_n946 B0=n950 B1=n2059
+ Y=n1592
XU563 AO22X1TR $PINS A0=FE_OFN121_n908 A1=FE_OFN46_n947 B0=n1007 B1=n2087
+ Y=n1617
XU564 AO22X1TR $PINS A0=FE_OFN127_n928 A1=FE_OFN61_n947 B0=n950 B1=n2099
+ Y=n1628
XU565 NAND2X1TR $PINS A=n733 B=n732 Y=n734
XU566 OR2X4TR $PINS A=n733 B=n732 Y=n735
XU567 NAND2X1TR $PINS A=n666 B=n665 Y=PE_top0_buff_mult_arr0_mult_x_24_n30
XU568 AO22X1TR $PINS A0=FE_OFN52_n902 A1=FE_OFN40_n944 B0=n960 B1=n1963 Y=n1505
XU569 AO22X1TR $PINS A0=n911 A1=FE_OFN41_n944 B0=n966 B1=n1969 Y=n1511
XU570 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN43_n945 B0=n960 B1=n2003
+ Y=n1541
XU571 AO22X1TR $PINS A0=n911 A1=FE_OFN42_n945 B0=n966 B1=n2009 Y=n1547
XU572 AO22X1TR $PINS A0=FE_OFN124_n902 A1=FE_OFN44_n946 B0=n960 B1=n2043
+ Y=n1577
XU573 AO22X1TR $PINS A0=n911 A1=FE_OFN45_n946 B0=n966 B1=n2049 Y=n1583
XU574 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN61_n947 B0=n960 B1=n2083
+ Y=n1613
XU575 AO22X1TR $PINS A0=n911 A1=FE_OFN47_n947 B0=n966 B1=n2089 Y=n1619
XU576 AO22X1TR $PINS A0=n899 A1=FE_OFN58_n882 B0=n1005 B1=n1801 Y=n1359
XU577 AO22X1TR $PINS A0=FE_OFN125_n902 A1=FE_OFN59_n882 B0=n960 B1=n1803
+ Y=n1361
XU578 AO22X1TR $PINS A0=FE_OFN119_n908 A1=n882 B0=n1007 B1=n1807 Y=n1365
XU579 AO22X1TR $PINS A0=FE_OFN126_n928 A1=FE_OFN59_n882 B0=n950 B1=n1819
+ Y=n1376
XU580 NOR2X1TR $PINS A=n641 B=n640 Y=PE_top0_DP_OP_17J1_122_4844_n31
XU581 NAND2X1TR $PINS A=n773 B=n772 Y=PE_top0_buff_mult_arr0_mult_x_33_n20
XU582 NAND2X1TR $PINS A=n673 B=n672 Y=PE_top0_buff_mult_arr0_mult_x_33_n30
XU583 NAND2BX1TR $PINS AN=n54 B=n777 Y=PE_top0_buff_mult_arr0_mult_x_30_n27
XU584 NOR2X1TR $PINS A=n658 B=n819 Y=PE_top0_buff_mult_arr0_mult_x_27_n22
XU585 NAND2X1TR $PINS A=n838 B=n837 Y=PE_top0_buff_mult_arr0_mult_x_24_n20
XU586 AND2X1TR $PINS A=n1759 B=FE_OFN143_reset Y=PE_top0_ST_ADD<1>
XU587 AND2X1TR $PINS A=n1758 B=FE_OFN143_reset Y=PE_top0_ST_ADD<2>
XU588 AND2X2TR $PINS A=n1048 B=n69 Y=n2157
XU589 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2114 B0=FE_OFN7_n60 B1=n2115 Y=n66
XU590 AND2X1TR $PINS A=n1719 B=FE_OFN26_FE_DBTN3_reset Y=PE_top0_OUT_ADD<1>
XU591 AND2X1TR $PINS A=n1083 B=FE_OFN26_FE_DBTN3_reset Y=PE_top0_OUT_ADD<2>
XU592 INVX1TR $PINS A=n1713 Y=n1089
XU593 NOR2BX1TR $PINS AN=n845 B=FE_OFN28_FE_DBTN3_reset Y=PE_top0_OUT_ADD<7>
XU594 INVX1TR $PINS A=n1027 Y=n1021
XU595 AND2X1TR $PINS A=pe_out_pk_data__0_ B=n744 Y=n859
XU596 AND2X1TR $PINS A=pe_out_pk_data__1_ B=n744 Y=n862
XU597 AND2X1TR $PINS A=n1764 B=FE_OFN143_reset Y=pe_out_pk_PE_state__2_
XU598 AND2X1TR $PINS A=n1765 B=FE_OFN143_reset Y=pe_out_pk_PE_state__1_
XU599 AND2X1TR $PINS A=n1766 B=FE_OFN143_reset Y=pe_out_pk_PE_state__0_
XU600 AND2X1TR $PINS A=n1760 B=FE_OFN143_reset Y=PE_top0_ST_ADD<0>
XU601 OAI2BB2XLTR $PINS A0N=n745 A1N=n2144 B0=n746 B1=n745 Y=n1671
XU602 NOR2X1TR $PINS A=n1764 B=n1765 Y=n744
XU603 NOR3X1TR $PINS A=n48 B=FE_OFN147_reset C=n1777 Y=n619
XU605 OAI21X1TR $PINS A0=n608 A1=n1277 B0=n607 Y=n49
XU606 OAI2BB1X4TR $PINS A0N=n1779 A1N=n1920 B0=n50 Y=n699
XU607 NAND2X2TR $PINS A=n1699 B=n1705 Y=n50
XU608 OAI22X4TR $PINS A0=n683 A1=n199 B0=n51 B1=n685 Y=n751
XU609 XNOR2X4TR $PINS A=n1301 B=n1302 Y=n132
XU610 XOR2X1TR $PINS A=n125 B=n560 Y=n572
XU611 OAI2BB1X4TR $PINS A0N=n1781 A1N=n1857 B0=n52 Y=n471
XU612 NAND2BX2TR $PINS AN=n53 B=n1681 Y=n52
XU613 NAND2X1TR $PINS A=n2040 B=n1779 Y=n55
XU614 OAI2BB1X4TR $PINS A0N=n1705 A1N=n1702 B0=n55 Y=n390
XU615 INVX4TR $PINS A=n223 Y=n252
XU616 OAI22X2TR $PINS A0=n221 A1=n713 B0=n222 B1=n56 Y=n647
XU617 OAI22X4TR $PINS A0=n646 A1=n713 B0=n220 B1=n56 Y=n648
XU618 OAI22X4TR $PINS A0=n645 A1=n56 B0=n713 B1=n406 Y=n401
XU619 OAI22X1TR $PINS A0=n645 A1=n713 B0=n646 B1=n56 Y=n662
XU620 NAND2X4TR $PINS A=n713 B=n218 Y=n56
XU621 AOI21X2TR $PINS A0=n697 A1=n696 B0=n695
+ Y=PE_top0_buff_mult_arr0_mult_x_33_n1
XU622 OR2X8TR $PINS A=n441 B=n442 Y=n448
XU623 NAND2X1TR $PINS A=n1678 B=n1708 Y=n57
XU624 OAI2BB1X4TR $PINS A0N=n1782 A1N=n2062 B0=n57 Y=n507
XU625 XOR2X1TR $PINS A=n1299 B=n1298 Y=n123
XU626 ADDFHX2TR $PINS A=n817 B=n816 CI=n815 S=n658
XU627 NAND2X2TR $PINS A=n344 B=n343 Y=n784
XU628 NOR2X1TR $PINS A=n283 B=FE_OFN0_FE_DBTN0_n2107 Y=n284
XU629 XOR2X1TR $PINS A=n282 B=n1309 Y=n283
XU630 OR2X2TR $PINS A=n465 B=n112 Y=n113
XU631 OAI21X1TR $PINS A0=n611 A1=n1294 B0=n1288 Y=n598
XU632 AO22X4TR $PINS A0=n1708 A1=n1673 B0=n1782 B1=n1862 Y=n205
XU633 AOI21X2TR $PINS A0=n448 A1=n447 B0=n446 Y=n449
XU634 NAND2X1TR $PINS A=n906 B=pe_in_pk_wrb__3_ Y=n874
XU635 INVX1TR $PINS A=n1313 Y=n584
XU636 OA21XLTR $PINS A0=n1287 A1=n1288 B0=n1293 Y=n609
XU637 INVX1TR $PINS A=n1310 Y=n78
XU638 OAI21X1TR $PINS A0=n1337 A1=n580 B0=n579 Y=n581
XU639 NAND2X1TR $PINS A=n70 B=n1334 Y=n71
XU640 OAI22X1TR $PINS A0=n682 A1=n200 B0=n507 B1=n679 Y=n414
XU641 OAI22X1TR $PINS A0=n573 A1=n560 B0=n129 B1=n46 Y=n561
XU642 AO21X2TR $PINS A0=n409 A1=n408 B0=n407 Y=n730
XU643 NAND2X1TR $PINS A=n416 B=n415 Y=n417
XU645 OAI21X1TR $PINS A0=n917 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n902
XU646 OR2X2TR $PINS A=n195 B=n194 Y=n197
XU649 NOR3X1TR $PINS A=pe_in_pk_rdb_addr__0_ B=FE_OCPN150_pe_in_pk_rdb_addr__2
+ C=n61 Y=n153
XU650 NOR3X4TR $PINS A=FE_OCPN150_pe_in_pk_rdb_addr__2
+ B=FE_OCPN231_pe_in_pk_rdb_addr__1 C=n63 Y=n154
XU652 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2118 B0=FE_OFN16_n154 B1=n2119 Y=n68
XU653 AND2X2TR $PINS A=n62 B=n58 Y=n155
XU655 AND3X2TR $PINS A=n63 B=n61 C=FE_OCPN150_pe_in_pk_rdb_addr__2 Y=n156
XU656 AOI22X1TR $PINS A0=n155 A1=n2117 B0=n156 B1=n2116 Y=n67
XU657 NOR3X1TR $PINS A=pe_in_pk_rdb_addr__0_ B=n62 C=n61 Y=n157
XU658 NOR3X1TR $PINS A=n63 B=n62 C=FE_OCPN231_pe_in_pk_rdb_addr__1 Y=n60
XU659 NOR3X1TR $PINS A=n63 B=n62 C=n61 Y=n147
XU660 NOR3BX1TR $PINS AN=n63 B=pe_in_pk_rdb_addr__1_ C=pe_in_pk_rdb_addr__2_
+ Y=n64
XU661 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2134 B0=FE_OFN10_n64 B1=n2122 Y=n65
XU662 NAND4X1TR $PINS A=n68 B=n67 C=n66 D=n65 Y=n69
XU663 INVX1TR $PINS A=n1333 Y=n70
XU664 NOR2BX1TR $PINS AN=n77 B=FE_OFN148_reset Y=n94
XU665 NAND2X1TR $PINS A=n78 B=n1311 Y=n79
XU666 XOR2X1TR $PINS A=n79 B=n281 Y=n80
XU667 NOR2BX2TR $PINS AN=n81 B=FE_OFN147_reset Y=n280
XU668 CLKINVX2TR $PINS A=n1276 Y=n82
XU669 NAND2X1TR $PINS A=n82 B=n1275 Y=n83
XU670 NOR2BX1TR $PINS AN=n84 B=FE_DBTN0_n2107 Y=n85
XU671 NOR2BX1TR $PINS AN=n85 B=FE_OFN148_reset Y=n279
XU673 NAND2X1TR $PINS A=n86 B=n1292 Y=n87
XU675 NOR2BX1TR $PINS AN=n90 B=FE_DBTN0_n2107 Y=n91
XU676 NOR2BX1TR $PINS AN=n91 B=FE_DBTN3_reset Y=n257
XU677 NOR2BX1TR $PINS AN=n1771 B=FE_DBTN0_n2107 Y=n93
XU678 NOR2BX1TR $PINS AN=n93 B=FE_DBTN3_reset Y=n260
XU679 CMPR32X2TR $PINS A=n96 B=n95 C=n94 S=n255 CO=n295
XU680 XOR2X1TR $PINS A=n1283 B=n1282 Y=n98
XU682 XNOR2X4TR $PINS A=n1283 B=n1284 Y=n97
XU683 AO22X4TR $PINS A0=n1707 A1=n1682 B0=n1781 B1=n1897 Y=n299
XU684 XOR2X1TR $PINS A=n1279 B=n1278 Y=n100
XU685 XNOR2X4TR $PINS A=n1279 B=n1280 Y=n465
XU686 NAND2X2TR $PINS A=n100 B=n465 Y=n467
XU687 AO22X4TR $PINS A0=n1707 A1=n1686 B0=n1781 B1=n2057 Y=n305
XU689 XNOR2X1TR $PINS A=n1278 B=n305 Y=n109
XU690 AO22X2TR $PINS A0=n1707 A1=n1685 B0=n1781 B1=n2017 Y=n338
XU691 OAI22X2TR $PINS A0=n467 A1=n109 B0=n465 B1=n104 Y=n118
XU692 OR2X2TR $PINS A=n119 B=n118 Y=n488
XU693 CLKINVX2TR $PINS A=n1281 Y=n101
XU694 XNOR2X1TR $PINS A=n101 B=n1282 Y=n102
XU695 CLKINVX4TR $PINS A=n102 Y=n474
XU696 AO22X2TR $PINS A0=n1707 A1=n1683 B0=n1781 B1=n1937 Y=n463
XU697 OAI22X4TR $PINS A0=n476 A1=n106 B0=n474 B1=n475 Y=n470
XU698 AO22X2TR $PINS A0=n1707 A1=n1684 B0=n1781 B1=n1977 Y=n321
XU699 XNOR2X1TR $PINS A=n1278 B=n321 Y=n466
XU700 OAI22X2TR $PINS A0=n116 A1=n476 B0=n474 B1=n106 Y=n122
XU701 INVX2TR $PINS A=n1285 Y=n345
XU702 NAND2X4TR $PINS A=n1284 B=n345 Y=n348
XU703 AO22X4TR $PINS A0=n1707 A1=n1687 B0=n1781 B1=n2097 Y=n108
XU705 XNOR2X1TR $PINS A=n1278 B=n108 Y=n110
XU706 OAI22X1TR $PINS A0=n467 A1=n110 B0=n109 B1=n465 Y=n298
XU707 OR2X2TR $PINS A=n467 B=n111 Y=n114
XU708 NAND2BX1TR $PINS AN=n108 B=n1278 Y=n112
XU709 NAND2X1TR $PINS A=n114 B=n113 Y=n297
XU710 XNOR2X1TR $PINS A=n1284 B=n471 Y=n300
XU711 XNOR2X1TR $PINS A=n1280 B=n338 Y=n306
XU712 XNOR2X1TR $PINS A=n1282 B=n463 Y=n301
XU713 XNOR2X2TR $PINS A=n119 B=n118 Y=n529
XU714 ADDFHX4TR $PINS A=n122 B=n121 CI=n120 S=n528 CO=n486
XU715 NOR2X1TR $PINS A=n789 B=n788 Y=PE_top0_buff_mult_arr0_mult_x_30_n19
XU716 XNOR2X2TR $PINS A=n1299 B=n1300 Y=n183
XU717 NAND2X4TR $PINS A=n123 B=n183 Y=n185
XU718 AO22X4TR $PINS A0=n1706 A1=n1695 B0=n1780 B1=n2078 Y=n124
XU719 AO22X4TR $PINS A0=n1706 A1=n1694 B0=n1780 B1=n2038 Y=n125
XU721 XNOR2X2TR $PINS A=n1298 B=n125 Y=n184
XU722 OAI22X2TR $PINS A0=n185 A1=n126 B0=n183 B1=n184 Y=n193
XU723 CLKINVX2TR $PINS A=n1298 Y=n128
XU724 NAND2BX1TR $PINS AN=n124 B=n1298 Y=n127
XU725 OAI22X1TR $PINS A0=n185 A1=n128 B0=n183 B1=n127 Y=n192
XU727 CLKINVX6TR $PINS A=n1305 Y=n566
XU728 NAND2X2TR $PINS A=n1304 B=n566 Y=n569
XU729 OAI22X4TR $PINS A0=n569 A1=n264 B0=n131 B1=n566 Y=n142
XU730 XNOR2X4TR $PINS A=n1303 B=n1304 Y=n129
XU732 NAND2X4TR $PINS A=n130 B=n129 Y=n573
XU733 AO22X4TR $PINS A0=n1706 A1=n1692 B0=n1780 B1=n1958 Y=n555
XU734 AO22X4TR $PINS A0=n1706 A1=n1691 B0=n1780 B1=n1918 Y=n165
XU735 OAI22X1TR $PINS A0=n573 A1=n265 B0=n129 B1=n134 Y=n141
XU736 OAI22X4TR $PINS A0=n569 A1=n131 B0=n191 B1=n566 Y=n457
XU737 XOR2X1TR $PINS A=n1301 B=n1300 Y=n133
XU738 NAND2X4TR $PINS A=n133 B=n132 Y=n190
XU740 OAI22X4TR $PINS A0=n190 A1=n135 B0=n132 B1=n189 Y=n456
XU741 OAI22X2TR $PINS A0=n573 A1=n134 B0=n129 B1=n181 Y=n455
XU742 XNOR2X1TR $PINS A=n1300 B=n125 Y=n137
XU743 OAI22X1TR $PINS A0=n190 A1=n137 B0=n132 B1=n135 Y=n136
XU744 OAI22X2TR $PINS A0=n190 A1=n138 B0=n132 B1=n137 Y=n267
XU745 CLKINVX2TR $PINS A=n1300 Y=n140
XU746 NAND2BX1TR $PINS AN=n124 B=n1300 Y=n139
XU747 OAI22X2TR $PINS A0=n190 A1=n140 B0=n132 B1=n139 Y=n266
XU748 ADDFHX4TR $PINS A=n143 B=n142 CI=n141 S=n262 CO=n656
XU750 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n2139 B0=FE_OFN17_n154 B1=n2140
+ Y=n151
XU752 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n2138 B0=FE_OFN60_n156 B1=n2137
+ Y=n150
XU753 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n2135 B0=FE_OFN88_n60 B1=n2136 Y=n149
XU755 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n2131 B0=FE_OFN142_n64 B1=n2104
+ Y=n148
XU756 NAND4X1TR $PINS A=n151 B=n150 C=n149 D=n148 Y=n152
XU757 AND2X2TR $PINS A=n1048 B=n152 Y=n2177
XU759 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2112 B0=FE_OFN16_n154 B1=n2113
+ Y=n162
XU761 AOI22X1TR $PINS A0=n155 A1=n2111 B0=n156 B1=n2109 Y=n161
XU762 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2106 B0=FE_OFN7_n60 B1=n2108 Y=n160
XU763 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n2105 B0=FE_OFN9_n64 B1=n2110 Y=n159
XU764 NAND4X1TR $PINS A=n162 B=n161 C=n160 D=n159 Y=n163
XU765 AND2X2TR $PINS A=n1048 B=n163 Y=n2147
XU766 XNOR2X1TR $PINS A=n1298 B=n555 Y=n168
XU767 XNOR2X1TR $PINS A=n1298 B=n165 Y=n164
XU768 OAI22X1TR $PINS A0=n185 A1=n168 B0=n183 B1=n164 Y=n179
XU769 XNOR2X2TR $PINS A=n1300 B=n165 Y=n188
XU770 OAI22X4TR $PINS A0=n190 A1=n188 B0=n173 B1=n132 Y=n187
XU771 OAI22X4TR $PINS A0=n185 A1=n182 B0=n183 B1=n168 Y=n186
XU772 OAI22X1TR $PINS A0=n180 A1=n573 B0=n174 B1=n129 Y=n177
XU773 OAI22X1TR $PINS A0=n181 A1=n573 B0=n129 B1=n180 Y=n459
XU774 ADDFHX4TR $PINS A=n186 B=n187 CI=n17 S=n453 CO=n178
XU775 CMPR22X2TR $PINS A=n193 B=n192 S=n657 CO=n460
XU776 NAND2X1TR $PINS A=n195 B=n194 Y=n196
XU777 NAND2X2TR $PINS A=n197 B=n196 Y=PE_top0_buff_mult_arr0_mult_x_27_n2
XU778 XOR2X1TR $PINS A=n1263 B=n1262 Y=n198
XU780 XNOR2X4TR $PINS A=n1263 B=n1264 Y=n199
XU781 AO22X4TR $PINS A0=n1708 A1=n1677 B0=n1782 B1=n2022 Y=n493
XU782 AO22X4TR $PINS A0=n1708 A1=n1679 B0=n1782 B1=n2102 Y=n200
XU783 OAI22X4TR $PINS A0=n685 A1=n202 B0=n199 B1=n201 Y=n212
XU784 NAND2BX1TR $PINS AN=n200 B=n1262 Y=n203
XU785 XNOR2X4TR $PINS A=n1261 B=n1262 Y=n518
XU786 NAND2X2TR $PINS A=n1266 B=n679 Y=n682
XU787 AO22X4TR $PINS A0=n1708 A1=n1674 B0=n1782 B1=n1902 Y=n504
XU789 XOR2X1TR $PINS A=n1265 B=n1264 Y=n207
XU790 XNOR2X4TR $PINS A=n1265 B=n1266 Y=n206
XU793 AO22X4TR $PINS A0=n1708 A1=n1676 B0=n1782 B1=n1982 Y=n509
XU794 XNOR2X1TR $PINS A=n1264 B=n509 Y=n210
XU795 AO22X4TR $PINS A0=n1708 A1=n1675 B0=n1782 B1=n1942 Y=n492
XU796 OAI22X2TR $PINS A0=n208 A1=n210 B0=FE_OCPN149_n206 B1=n688 Y=n676
XU797 OAI22X4TR $PINS A0=n208 A1=n429 B0=FE_OCPN149_n206 B1=n210 Y=n436
XU798 CMPR22X2TR $PINS A=n212 B=n211 S=n435 CO=n691
XU799 AO22X4TR $PINS A0=n1705 A1=n1698 B0=n1779 B1=n1880 Y=n701
XU802 AO22X4TR $PINS A0=n1705 A1=n1701 B0=n1779 B1=n2000 Y=n403
XU803 XNOR2X1TR $PINS A=n403 B=n1323 Y=n225
XU804 AO22X4TR $PINS A0=n1705 A1=n1700 B0=n1779 B1=n1960 Y=n698
XU805 XNOR2X1TR $PINS A=n1323 B=n698 Y=n396
XU806 XNOR2X4TR $PINS A=n216 B=n1323 Y=n217
XU807 CLKINVX6TR $PINS A=n217 Y=n713
XU808 AO22X4TR $PINS A0=n1705 A1=n1703 B0=n1779 B1=n2080 Y=n219
XU809 XNOR2X2TR $PINS A=n1321 B=n219 Y=n220
XU810 CLKINVX2TR $PINS A=n1321 Y=n222
XU811 OAI22X2TR $PINS A0=n409 A1=n230 B0=n224 B1=n408 Y=n228
XU812 OAI22X1TR $PINS A0=n215 A1=n231 B0=n213 B1=n225 Y=n227
XU813 OAI22X1TR $PINS A0=n409 A1=n219 B0=n390 B1=n408 Y=n236
XU814 INVX1TR $PINS A=n234 Y=n235
XU815 OAI21X1TR $PINS A0=n241 A1=n240 B0=n239 Y=n1061
XU816 AOI21X2TR $PINS A0=n1061 A1=n1060 B0=n248 Y=n659
XU817 AOI21X2TR $PINS A0=n836 A1=n13 B0=n834 Y=n253
XU818 ADDFX2TR $PINS A=n257 B=n256 CI=n255 S=n1054 CO=n640
XU819 NOR2BX1TR $PINS AN=n1776 B=FE_DBTN0_n2107 Y=n258
XU820 NOR2BX1TR $PINS AN=n258 B=FE_DBTN3_reset Y=n536
XU821 NOR2BX1TR $PINS AN=n1773 B=FE_DBTN0_n2107 Y=n259
XU822 NOR2BX1TR $PINS AN=n259 B=FE_DBTN3_reset Y=n535
XU823 ADDHX1TR $PINS A=n261 B=n260 S=n534 CO=n256
XU824 NOR2X1TR $PINS A=n1054 B=n1053 Y=PE_top0_DP_OP_17J1_122_4844_n34
XU825 ADDFHX4TR $PINS A=n136 B=n263 CI=n262 S=n797 CO=n144
XU826 OAI22X2TR $PINS A0=n569 A1=n567 B0=n264 B1=n566 Y=n800
XU827 OAI22X2TR $PINS A0=n573 A1=n570 B0=n129 B1=n265 Y=n799
XU828 CMPR22X2TR $PINS A=n267 B=n266 S=n798 CO=n263
XU829 NAND2X1TR $PINS A=n797 B=n796 Y=PE_top0_buff_mult_arr0_mult_x_27_n30
XU830 NOR2X1TR $PINS A=n1027 B=n1029 Y=n270
XU831 NAND2X1TR $PINS A=n1727 B=n2141 Y=n1026
XU832 NAND2X1TR $PINS A=n1728 B=n2142 Y=n1030
XU833 OAI21X1TR $PINS A0=n1029 A1=n1026 B0=n1030 Y=n269
XU834 AOI21X1TR $PINS A0=n270 A1=n1025 B0=n269 Y=n867
XU835 NOR2X1TR $PINS A=n1729 B=n1750 Y=n863
XU836 NAND2X1TR $PINS A=n1729 B=n1750 Y=n864
XU837 OAI21X1TR $PINS A0=n867 A1=n863 B0=n864 Y=n1039
XU838 NAND2X1TR $PINS A=n1730 B=n2143 Y=n1036
XU839 INVX1TR $PINS A=n1036 Y=n271
XU840 AOI21X1TR $PINS A0=n1039 A1=n1037 B0=n271 Y=n738
XU841 NOR2X1TR $PINS A=n1731 B=n1751 Y=n737
XU842 NAND2X1TR $PINS A=n1731 B=n1751 Y=n736
XU843 NAND2X1TR $PINS A=n272 B=n736 Y=n273
XU844 XOR2X1TR $PINS A=n738 B=n273 Y=n274
XU845 OAI21X1TR $PINS A0=n1327 A1=n1333 B0=n1334 Y=n275
XU846 XNOR2X1TR $PINS A=n275 B=n1332 Y=n276
XU847 NOR2BX1TR $PINS AN=n276 B=FE_DBTN0_n2107 Y=n277
XU848 NOR2BX1TR $PINS AN=n277 B=FE_DBTN3_reset Y=n388
XU849 ADDFHX2TR $PINS A=n280 B=n279 CI=n278 S=n294 CO=n387
XU850 OAI21X1TR $PINS A0=n281 A1=n1310 B0=n1311 Y=n282
XU851 OAI21X1TR $PINS A0=n1268 A1=n1276 B0=n1275 Y=n285
XU852 XNOR2X1TR $PINS A=n285 B=n1274 Y=n286
XU853 NOR2BX1TR $PINS AN=n287 B=FE_OFN148_reset Y=n384
XU854 OAI21X1TR $PINS A0=n288 A1=n1291 B0=n1292 Y=n291
XU855 INVX1TR $PINS A=n1289 Y=n289
XU856 NAND2X1TR $PINS A=n289 B=n1290 Y=n290
XU857 XNOR2X1TR $PINS A=n291 B=n290 Y=n292
XU859 NOR2BX1TR $PINS AN=n293 B=FE_OFN147_reset Y=n383
XU860 ADDFHX1TR $PINS A=n296 B=n295 CI=n294 S=n641 CO=n1051
XU861 NOR2X1TR $PINS A=n1052 B=n1051 Y=PE_top0_DP_OP_17J1_122_4844_n27
XU862 CMPR22X2TR $PINS A=n298 B=n297 S=n533 CO=n120
XU863 NOR2BX1TR $PINS AN=n108 B=n465 Y=n312
XU864 OAI22X2TR $PINS A0=n348 A1=n346 B0=n300 B1=n345 Y=n311
XU865 XNOR2X1TR $PINS A=n1282 B=n321 Y=n349
XU866 OAI22X2TR $PINS A0=n99 A1=n349 B0=n97 B1=n301 Y=n310
XU867 ADDFHX2TR $PINS A=n304 B=n303 CI=n302 S=n531 CO=n530
XU868 XNOR2X1TR $PINS A=n1280 B=n305 Y=n307
XU869 OAI22X1TR $PINS A0=n476 A1=n307 B0=n474 B1=n306 Y=n780
XU870 XNOR2X1TR $PINS A=n1280 B=n108 Y=n308
XU871 OAI22X2TR $PINS A0=n476 A1=n308 B0=n474 B1=n307 Y=n352
XU872 NAND2BX1TR $PINS AN=n108 B=n1280 Y=n309
XU873 OAI22X2TR $PINS A0=n476 A1=n5 B0=n474 B1=n309 Y=n351
XU874 CMPR32X2TR $PINS A=n312 B=n311 C=n310 S=n778 CO=n532
XU875 NOR2X1TR $PINS A=n777 B=n776 Y=PE_top0_buff_mult_arr0_mult_x_30_n26
XU876 OAI22X1TR $PINS A0=n348 A1=n305 B0=n322 B1=n345 Y=n317
XU877 INVX1TR $PINS A=n313 Y=n314
XU878 OAI21X2TR $PINS A0=n320 A1=n319 B0=n318 Y=n1071
XU879 OAI22X4TR $PINS A0=n348 A1=n322 B0=n14 B1=n345 Y=n342
XU880 NAND2X1TR $PINS A=n1282 B=n108 Y=n325
XU881 INVX2TR $PINS A=n108 Y=n323
XU882 NAND2X1TR $PINS A=n331 B=n323 Y=n324
XU883 NAND2X1TR $PINS A=n325 B=n324 Y=n329
XU884 INVX1TR $PINS A=n97 Y=n328
XU885 XNOR2X1TR $PINS A=n1282 B=n305 Y=n340
XU886 CLKINVX2TR $PINS A=n340 Y=n327
XU887 OAI2BB2X2TR $PINS A0N=n328 A1N=n327 B0=n99 B1=n329 Y=n341
XU888 OAI22X1TR $PINS A0=n99 A1=n331 B0=n97 B1=n330 Y=n332
XU889 NAND2X1TR $PINS A=n333 B=n332 Y=n1069
XU890 INVX2TR $PINS A=n1069 Y=n334
XU891 AOI21X2TR $PINS A0=n1071 A1=n1070 B0=n334 Y=n365
XU892 INVX2TR $PINS A=n365 Y=n787
XU893 OAI22X4TR $PINS A0=n348 A1=n14 B0=n347 B1=n345 Y=n355
XU894 NOR2BX2TR $PINS AN=n108 B=n474 Y=n354
XU895 XNOR2X1TR $PINS A=n1282 B=n338 Y=n350
XU896 OAI22X2TR $PINS A0=n99 A1=n340 B0=n97 B1=n350 Y=n353
XU897 ADDHX1TR $PINS A=n342 B=n341 S=n333 CO=n343
XU898 OR2X4TR $PINS A=n344 B=n343 Y=n785
XU899 CLKINVX2TR $PINS A=n784 Y=n362
XU900 AOI21X2TR $PINS A0=n787 A1=n785 B0=n362 Y=n359
XU901 OAI22X4TR $PINS A0=n99 A1=n350 B0=n97 B1=n349 Y=n782
XU902 ADDHX1TR $PINS A=n352 B=n351 S=n781 CO=n779
XU903 ADDFHX2TR $PINS A=n355 B=n354 CI=n353 S=n344 CO=n356
XU904 NAND2X1TR $PINS A=n357 B=n356 Y=n360
XU905 NAND2X2TR $PINS A=n360 B=n363 Y=n358
XU906 XOR2X1TR $PINS A=n359 B=n358
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<5>
XU907 NAND2X1TR $PINS A=n363 B=n785 Y=n366
XU908 INVX1TR $PINS A=n360 Y=n361
XU909 AOI21X1TR $PINS A0=n363 A1=n362 B0=n361 Y=n364
XU910 OAI21X1TR $PINS A0=n366 A1=n365 B0=n364
+ Y=PE_top0_buff_mult_arr0_mult_x_30_n32
XU911 INVX1TR $PINS A=n1330 Y=n367
XU912 NAND2X1TR $PINS A=n367 B=n1331 Y=n368
XU913 NOR2BX1TR $PINS AN=n369 B=FE_DBTN0_n2107 Y=n370
XU914 NOR2BX1TR $PINS AN=n370 B=FE_DBTN3_reset Y=n853
XU915 NOR2X2TR $PINS A=n1289 B=n1291 Y=n372
XU916 OAI21X2TR $PINS A0=n1289 A1=n1292 B0=n1290 Y=n371
XU917 AOI21X4TR $PINS A0=n372 A1=n1296 B0=n371 Y=n611
XU918 NOR2BX1TR $PINS AN=n373 B=FE_OFN0_FE_DBTN0_n2107 Y=n374
XU919 NOR2BX2TR $PINS AN=n374 B=FE_OFN147_reset Y=n632
XU920 INVX2TR $PINS A=n1272 Y=n375
XU921 NAND2X1TR $PINS A=n375 B=n1273 Y=n376
XU922 XOR2X1TR $PINS A=n1277 B=n376 Y=n377
XU923 NOR2BX1TR $PINS AN=n377 B=n1777 Y=n378
XU924 NOR2BX1TR $PINS AN=n378 B=FE_OFN148_reset Y=n631
XU925 AND2X2TR $PINS A=n1312 B=n1317 Y=n379
XU926 NOR2X2TR $PINS A=n1316 B=n379 Y=n603
XU927 NOR2BX1TR $PINS AN=n381 B=FE_OFN0_FE_DBTN0_n2107 Y=n382
XU928 NOR2BX1TR $PINS AN=n382 B=FE_OFN147_reset Y=n630
XU929 ADDFHX2TR $PINS A=n388 B=n387 CI=n386 S=n1052 CO=n1049
XU930 NOR2X1TR $PINS A=n1050 B=n1049 Y=PE_top0_DP_OP_17J1_122_4844_n24
XU931 XOR2X1TR $PINS A=n1320 B=n1319 Y=n389
XU932 NAND2X2TR $PINS A=n389 B=n704 Y=n706
XU933 OAI22X2TR $PINS A0=n706 A1=n391 B0=n704 B1=n404 Y=n411
XU934 NAND2BX2TR $PINS AN=n219 B=n1319 Y=n392
XU935 OAI22X2TR $PINS A0=n706 A1=n393 B0=n704 B1=n392 Y=n410
XU936 NOR2BX1TR $PINS AN=n219 B=n704 Y=n651
XU937 AO22X4TR $PINS A0=n1705 A1=n1697 B0=n1779 B1=n1840 Y=n710
XU938 OAI22X4TR $PINS A0=n409 A1=n395 B0=n398 B1=n408 Y=n650
XU939 OAI22X4TR $PINS A0=n409 A1=n398 B0=n407 B1=n408 Y=n402
XU940 XNOR2X1TR $PINS A=n1321 B=n403 Y=n645
XU942 XNOR2X1TR $PINS A=n1323 B=n701 Y=n405
XU943 ADDFHX2TR $PINS A=n401 B=n402 CI=n400 S=n642 CO=n827
XU944 XNOR2X1TR $PINS A=n1319 B=n403 Y=n705
XU945 OAI22X1TR $PINS A0=n706 A1=n404 B0=n704 B1=n705 Y=n724
XU946 XNOR2X1TR $PINS A=n1323 B=n710 Y=n709
XU947 OAI22X1TR $PINS A0=n215 A1=n405 B0=n213 B1=n709 Y=n725
XU948 XNOR2X1TR $PINS A=n724 B=n725 Y=n826
XU949 NOR2X2TR $PINS A=n829 B=n828 Y=PE_top0_buff_mult_arr0_mult_x_24_n22
XU950 OAI22X1TR $PINS A0=n682 A1=n507 B0=n421 B1=n679 Y=n416
XU951 NAND2BX1TR $PINS AN=n200 B=n1266 Y=n412
XU952 INVX1TR $PINS A=n412 Y=n413
XU953 OAI21X1TR $PINS A0=n419 A1=n418 B0=n417 Y=n1077
XU954 OAI22X2TR $PINS A0=n421 A1=n682 B0=n4 B1=n679 Y=n432
XU955 XNOR2X1TR $PINS A=n507 B=n1264 Y=n430
XU956 OAI22X1TR $PINS A0=n208 A1=n422 B0=FE_OCPN149_n206 B1=n430 Y=n431
XU957 OR2X4TR $PINS A=n426 B=n425 Y=n1076
XU958 NAND2X1TR $PINS A=n426 B=n425 Y=n1075
XU959 INVX2TR $PINS A=n1075 Y=n427
XU960 AOI21X2TR $PINS A0=n1077 A1=n1076 B0=n427 Y=n450
XU961 INVX2TR $PINS A=n450 Y=n768
XU962 NOR2BX1TR $PINS AN=n200 B=n199 Y=n440
XU963 OAI22X2TR $PINS A0=n682 A1=n4 B0=n428 B1=n679 Y=n439
XU964 OAI22X1TR $PINS A0=n208 A1=n430 B0=FE_OCPN149_n206 B1=n429 Y=n438
XU965 NAND2X2TR $PINS A=n434 B=n433 Y=n766
XU966 INVX2TR $PINS A=n766 Y=n447
XU967 AOI21X1TR $PINS A0=n768 A1=n767 B0=n447 Y=n444
XU968 ADDFHX4TR $PINS A=n437 B=n436 CI=n435 S=n441 CO=n672
XU969 NAND2X2TR $PINS A=n442 B=n441 Y=n445
XU970 XOR2X1TR $PINS A=n444 B=n443
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_MULT_single0_out_int<5>
XU971 INVX2TR $PINS A=n445 Y=n446
XU972 OAI21X2TR $PINS A0=n451 A1=n450 B0=n449 Y=n697
XU973 ADDFHX4TR $PINS A=n454 B=n453 CI=n452 S=n795 CO=n194
XU974 ADDFHX4TR $PINS A=n457 B=n456 CI=n455 S=n655 CO=n817
XU975 XNOR2X2TR $PINS A=n459 B=n458 Y=n816
XU976 CMPR32X2TR $PINS A=n462 B=n461 C=n460 S=n815 CO=n452
XU977 NOR2X1TR $PINS A=n795 B=n794 Y=PE_top0_buff_mult_arr0_mult_x_27_n19
XU978 XNOR2X1TR $PINS A=n1278 B=n463 Y=n464
XU979 OAI22X1TR $PINS A0=n467 A1=n466 B0=n465 B1=n464 Y=n485
XU980 ADDFHX4TR $PINS A=n470 B=n469 CI=n468 S=n487 CO=n484
XU981 XNOR2X1TR $PINS A=n1280 B=n471 Y=n473
XU982 AO21X1TR $PINS A0=n99 A1=n97 B0=n477 Y=n480
XU983 XOR3X2TR $PINS A=n482 B=n481 C=n480 Y=n483
XU984 ADDFHX2TR $PINS A=n488 B=n487 CI=n486 S=n789 CO=n790
XU985 XNOR2X1TR $PINS A=n1260 B=n492 Y=n491
XU986 XNOR2X1TR $PINS A=n1262 B=n504 Y=n496
XU987 XNOR2X1TR $PINS A=n1264 B=n512 Y=n497
XU988 OAI22X4TR $PINS A0=n208 A1=n506 B0=FE_OCPN149_n206 B1=n497 Y=n500
XU989 XNOR2X1TR $PINS A=n1262 B=n205 Y=n495
XU990 XNOR2X1TR $PINS A=n1264 B=n504 Y=n686
XU991 OAI22X1TR $PINS A0=n208 A1=n686 B0=FE_OCPN149_n206 B1=n506 Y=n754
XU992 XNOR2X1TR $PINS A=n1260 B=n507 Y=n514
XU993 OAI22X1TR $PINS A0=n520 A1=n514 B0=n518 B1=n508 Y=n753
XU994 XNOR2X2TR $PINS A=n1262 B=n509 Y=n683
XU995 OAI22X2TR $PINS A0=n685 A1=n683 B0=n199 B1=n511 Y=n757
XU996 XNOR2X1TR $PINS A=n1266 B=n512 Y=n680
XU997 AO21X2TR $PINS A0=n682 A1=n679 B0=n680 Y=n756
XU998 XNOR2X1TR $PINS A=n1260 B=n200 Y=n515
XU999 NAND2BX1TR $PINS AN=n200 B=n1260 Y=n517
XU1000 ADDFHX4TR $PINS A=n530 B=n529 CI=n528 S=n774 CO=n788
XU1001 ADDFHX2TR $PINS A=n533 B=n532 CI=n531 S=n777 CO=n775
XU1002 NOR2X2TR $PINS A=n774 B=n775 Y=PE_top0_buff_mult_arr0_mult_x_30_n22
XU1003 ADDFX2TR $PINS A=n536 B=n535 CI=n534 S=n538 CO=n1053
XU1004 NOR2BX1TR $PINS AN=n1722 B=FE_DBTN3_reset Y=n541
XU1005 NOR2BX1TR $PINS AN=n1721 B=FE_OFN28_FE_DBTN3_reset Y=n540
XU1006 CLKINVX2TR $PINS A=n856 Y=n539
XU1007 NAND2X1TR $PINS A=n539 B=n854 Y=n545
XU1008 NOR2BX1TR $PINS AN=n1724 B=FE_DBTN3_reset Y=n543
XU1009 NOR2BX1TR $PINS AN=n1723 B=FE_DBTN3_reset Y=n542
XU1010 ADDHXLTR $PINS A=n541 B=n540 S=n1057 CO=n537
XU1011 OAI22X1TR $PINS A0=n569 A1=n124 B0=n125 B1=n566 Y=n549
XU1012 INVX1TR $PINS A=n547 Y=n548
XU1013 OAI21X1TR $PINS A0=n554 A1=n553 B0=n552 Y=n1066
XU1014 XNOR2X1TR $PINS A=n1304 B=n555 Y=n568
XU1015 OAI22X2TR $PINS A0=n569 A1=n557 B0=n568 B1=n566 Y=n575
XU1016 OR2X2TR $PINS A=n562 B=n561 Y=n1065
XU1017 NAND2X1TR $PINS A=n562 B=n561 Y=n1064
XU1018 AOI21X1TR $PINS A0=n1066 A1=n1065 B0=n563 Y=n808
XU1019 NOR2BX1TR $PINS AN=n124 B=n132 Y=n803
XU1020 OAI22X2TR $PINS A0=n569 A1=n568 B0=n567 B1=n566 Y=n802
XU1021 OAI22X1TR $PINS A0=n573 A1=n572 B0=n129 B1=n570 Y=n801
XU1022 NAND2X1TR $PINS A=n577 B=n576 Y=n810
XU1023 NAND2X1TR $PINS A=n812 B=n810 Y=n578
XU1024 XNOR2X1TR $PINS A=n581 B=n1328 Y=n582
XU1025 NOR2BX1TR $PINS AN=n582 B=FE_DBTN0_n2107 Y=n583
XU1026 OAI21X1TR $PINS A0=n603 A1=n1313 B0=n1314 Y=n587
XU1027 CLKINVX2TR $PINS A=n1307 Y=n585
XU1028 NAND2X1TR $PINS A=n585 B=n1308 Y=n586
XU1029 XNOR2X2TR $PINS A=n587 B=n586 Y=n588
XU1030 NOR2BX1TR $PINS AN=n588 B=FE_OFN0_FE_DBTN0_n2107 Y=n589
XU1031 NOR2BX4TR $PINS AN=n589 B=FE_OFN147_reset Y=n635
XU1032 OAI21X1TR $PINS A0=n1277 A1=n1272 B0=n1273 Y=n592
XU1033 INVX1TR $PINS A=n1270 Y=n590
XU1034 NAND2X1TR $PINS A=n590 B=n1271 Y=n591
XU1035 AND2X2TR $PINS A=n593 B=n1778 Y=n594
XU1036 INVX1TR $PINS A=n1287 Y=n596
XU1037 NAND2X1TR $PINS A=n596 B=n1293 Y=n597
XU1038 XNOR2X1TR $PINS A=n598 B=n597 Y=n599
XU1039 NOR2BX1TR $PINS AN=n599 B=FE_OFN0_FE_DBTN0_n2107 Y=n600
XU1040 NOR2BX2TR $PINS AN=n600 B=FE_OFN147_reset Y=n633
XU1041 OR2X2TR $PINS A=n1313 B=n1307 Y=n602
XU1042 OA21X2TR $PINS A0=n1307 A1=n1314 B0=n1308 Y=n601
XU1043 OAI21X2TR $PINS A0=n603 A1=n602 B0=n601 Y=n604
XU1044 XNOR2X4TR $PINS A=n604 B=n1306 Y=n605
XU1045 NOR2BX2TR $PINS AN=n605 B=FE_OFN0_FE_DBTN0_n2107 Y=n606
XU1046 NOR2BX2TR $PINS AN=n606 B=FE_OFN147_reset Y=n620
XU1047 OR2X2TR $PINS A=n1272 B=n1270 Y=n608
XU1048 OA21XLTR $PINS A0=n1270 A1=n1273 B0=n1271 Y=n607
XU1049 OR2X1TR $PINS A=n1294 B=n1287 Y=n610
XU1050 OAI21X1TR $PINS A0=n611 A1=n610 B0=n609 Y=n613
XU1051 NAND2X1TR $PINS A=n1286 B=n1295 Y=n612
XU1052 XNOR2X1TR $PINS A=n613 B=n612 Y=n615
XU1053 NOR2BX1TR $PINS AN=n615 B=FE_OFN0_FE_DBTN0_n2107 Y=n617
XU1054 NOR2BX2TR $PINS AN=n617 B=FE_OFN147_reset Y=n618
XU1055 XOR3X2TR $PINS A=n620 B=n619 C=n618 Y=n621
XU1056 XOR3X2TR $PINS A=n623 B=n622 C=n621 Y=n637
XU1057 OAI21X1TR $PINS A0=n1337 A1=n1330 B0=n1331 Y=n626
XU1058 CLKINVX2TR $PINS A=n1329 Y=n624
XU1059 NOR2BX1TR $PINS AN=n628 B=FE_DBTN0_n2107 Y=n629
XU1060 ADDFHX2TR $PINS A=n632 B=n631 CI=n630 S=n852 CO=n849
XU1061 ADDFHX2TR $PINS A=n635 B=n634 CI=n633 S=n848 CO=n622
XU1062 OR2X4TR $PINS A=n637 B=n636 Y=n639
XU1063 NAND2X2TR $PINS A=n639 B=n638 Y=PE_top0_DP_OP_17J1_122_4844_n2
XU1064 ADDFHX4TR $PINS A=n644 B=n643 CI=n642 S=n653 CO=n829
XU1065 CMPR22X2TR $PINS A=n648 B=n647 S=n663 CO=n661
XU1066 ADDFHX4TR $PINS A=n651 B=n650 CI=n649 S=n660 CO=n643
XU1067 INVX1TR $PINS A=n668 Y=n654
XU1068 NAND2X1TR $PINS A=n654 B=n667 Y=PE_top0_buff_mult_arr0_mult_x_24_n5
XU1069 ADDFHX4TR $PINS A=n657 B=n656 CI=n655 S=n145 CO=n819
XU1070 ADDFHX2TR $PINS A=n662 B=n661 CI=n660 S=n666 CO=n652
XU1071 ADDFHX2TR $PINS A=n2 B=n664 CI=n663 S=n223 CO=n665
XU1072 NOR2X2TR $PINS A=n666 B=n665 Y=PE_top0_buff_mult_arr0_mult_x_24_n29
XU1073 NOR2X1TR $PINS A=n668 B=PE_top0_buff_mult_arr0_mult_x_24_n29 Y=n670
XU1074 NOR2X2TR $PINS A=n673 B=n672 Y=PE_top0_buff_mult_arr0_mult_x_33_n29
XU1075 OAI22X2TR $PINS A0=n682 A1=n681 B0=n680 B1=n679 Y=n752
XU1076 ADDFHX4TR $PINS A=n692 B=n691 CI=n690 S=n673 CO=n693
XU1077 NOR2X6TR $PINS A=n694 B=n693 Y=n769
XU1078 NAND2X2TR $PINS A=n694 B=n693 Y=n770
XU1079 OAI21X2TR $PINS A0=PE_top0_buff_mult_arr0_mult_x_33_n30 A1=n769 B0=n770
+ Y=n695
XU1080 XNOR2X1TR $PINS A=n1319 B=n698 Y=n703
XU1081 XNOR2X1TR $PINS A=n1319 B=n699 Y=n700
XU1082 OAI22X1TR $PINS A0=n706 A1=n703 B0=n704 B1=n700 Y=n723
XU1083 OAI22X4TR $PINS A0=n706 A1=n705 B0=n704 B1=n703 Y=n727
XU1084 OAI22X4TR $PINS A0=n215 A1=n709 B0=n213 B1=n715 Y=n720
XU1085 CLKINVX2TR $PINS A=n720 Y=n726
XU1086 XNOR2X1TR $PINS A=n1321 B=n710 Y=n712
XU1087 OR2X2TR $PINS A=n725 B=n724 Y=n824
XU1088 ADDFHX4TR $PINS A=n728 B=n727 CI=n726 S=n823 CO=n722
XU1089 ADDFHX2TR $PINS A=n729 B=n730 CI=n731 S=n825 CO=n822
XU1090 OAI21X1TR $PINS A0=n738 A1=n737 B0=n736 Y=n742
XU1091 NAND2X1TR $PINS A=n1732 B=n2144 Y=n739
XU1092 NAND2X1TR $PINS A=n740 B=n739 Y=n741
XU1093 NAND2X1TR $PINS A=pe_out_pk_data__7_ B=n744 Y=n746
XU1094 XNOR2X1TR $PINS A=n754 B=n753 Y=n759
XU1095 ADDFHX4TR $PINS A=n757 B=n756 CI=n755 S=n758 CO=n748
XU1096 NOR2X1TR $PINS A=n773 B=n772 Y=PE_top0_buff_mult_arr0_mult_x_33_n19
XU1097 ADDFHX2TR $PINS A=n760 B=n759 CI=n758 S=n765 CO=n772
XU1098 ADDFHX4TR $PINS A=n763 B=n762 CI=n761 S=n694 CO=n764
XU1099 NOR2X1TR $PINS A=n765 B=n764 Y=PE_top0_buff_mult_arr0_mult_x_33_n22
XU1100 NAND2X1TR $PINS A=n765 B=n764 Y=PE_top0_buff_mult_arr0_mult_x_33_n23
XU1101 NAND2X1TR $PINS A=n771 B=n770 Y=PE_top0_buff_mult_arr0_mult_x_33_n5
XU1102 NAND2X1TR $PINS A=n775 B=n774 Y=PE_top0_buff_mult_arr0_mult_x_30_n23
XU1103 ADDFHX2TR $PINS A=n783 B=n782 CI=n781 S=n357 CO=n792
XU1104 NOR2X1TR $PINS A=n793 B=n792 Y=PE_top0_buff_mult_arr0_mult_x_30_n29
XU1105 NAND2X1TR $PINS A=n785 B=n784 Y=n786
XU1106 XNOR2X1TR $PINS A=n787 B=n786
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_MULT_single0_out_int<4>
XU1107 NAND2X1TR $PINS A=n789 B=n788 Y=PE_top0_buff_mult_arr0_mult_x_30_n20
XU1108 OR2X4TR $PINS A=n791 B=n790 Y=n1297
XU1109 NAND2X1TR $PINS A=n793 B=n792 Y=PE_top0_buff_mult_arr0_mult_x_30_n30
XU1110 ADDFHX4TR $PINS A=n800 B=n799 CI=n798 S=n805 CO=n796
XU1111 ADDFHX1TR $PINS A=n803 B=n802 CI=n801 S=n577 CO=n804
XU1113 NAND2X1TR $PINS A=n821 B=n812 Y=n809
XU1114 OA21XLTR $PINS A0=n806 A1=n810 B0=n820 Y=n807
XU1115 OAI21X1TR $PINS A0=n809 A1=n808 B0=n807
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n32
XU1116 INVX1TR $PINS A=n810 Y=n811
XU1117 AOI21X1TR $PINS A0=n813 A1=n812 B0=n811
+ Y=PE_top0_buff_mult_arr0_mult_x_27_n39
XU1118 ADDFHX2TR $PINS A=n817 B=n816 CI=n815 S=n818 CO=n794
XU1119 NAND2X1TR $PINS A=n821 B=n820 Y=PE_top0_buff_mult_arr0_mult_x_27_n7
XU1120 ADDFHX4TR $PINS A=n824 B=n823 CI=n822 S=n838 CO=n732
XU1121 ADDFHX2TR $PINS A=n827 B=n826 CI=n825 S=n828 CO=n837
XU1122 NAND2X1TR $PINS A=n829 B=n828 Y=PE_top0_buff_mult_arr0_mult_x_24_n23
XU1123 NAND2X1TR $PINS A=n836 B=n835 Y=PE_top0_buff_mult_arr0_mult_x_24_n7
XU1124 OAI21X1TR $PINS A0=n1715 A1=n1718 B0=n1716 Y=n839
XU1125 AOI21X1TR $PINS A0=n840 A1=n1704 B0=n839 Y=n1100
XU1126 NAND2X1TR $PINS A=n1096 B=n1783 Y=n843
XU1127 AOI21X1TR $PINS A0=n1097 A1=n1783 B0=n841 Y=n842
XU1128 OAI21X1TR $PINS A0=n1100 A1=n843 B0=n842 Y=n844
XU1129 XNOR2X1TR $PINS A=n844 B=n1709 Y=n845
XU1130 NOR2BX1TR $PINS AN=n847 B=FE_OFN28_FE_DBTN3_reset Y=pe_out_pk_data__0_
XU1131 ADDFHX2TR $PINS A=n850 B=n849 CI=n848 S=n858 CO=n636
XU1132 ADDFHX2TR $PINS A=n853 B=n852 CI=n851 S=n1050 CO=n857
XU1133 OR2X2TR $PINS A=n858 B=n857 Y=n1339
XU1134 OAI21X1TR $PINS A0=n856 A1=n855 B0=n854
+ Y=PE_top0_DP_OP_17J1_122_4844_n37
XU1135 NAND2X1TR $PINS A=n858 B=n857 Y=PE_top0_DP_OP_17J1_122_4844_n18
XU1136 AO22X1TR $PINS A0=FE_OFN105_n871 A1=n859 B0=n745 B1=n1748 Y=n1340
XU1137 AFHCINX2TR $PINS A=n1749 B=n1726 CIN=n860 S=n861 CO=n1025
XU1138 AND2X2TR $PINS A=n861 B=FE_OFN26_FE_DBTN3_reset Y=pe_out_pk_data__1_
XU1139 AO22X1TR $PINS A0=FE_OFN105_n871 A1=n862 B0=n745 B1=n1749 Y=n1341
XU1140 NAND2X1TR $PINS A=n865 B=n864 Y=n866
XU1141 XOR2X1TR $PINS A=n867 B=n866 Y=n868
XU1142 AND2X2TR $PINS A=n868 B=FE_OFN26_FE_DBTN3_reset Y=pe_out_pk_data__4_
XU1143 AND2X2TR $PINS A=pe_out_pk_data__4_ B=n744 Y=n869
XU1144 AO22X1TR $PINS A0=FE_OFN104_n871 A1=n869 B0=n745 B1=n1750 Y=n1342
XU1145 NAND3X1TR $PINS A=FE_DBTN2_pe_in_pk_wrb_addr__0 B=n891 C=n6 Y=n873
XU1146 NAND2X2TR $PINS A=n873 B=pe_in_pk_wrb_addr__3_ Y=n906
XU1148 NOR2BX2TR $PINS AN=pe_in_pk_wrb_data__7_ B=FE_OFN6_reset Y=n882
XU1149 AO22X1TR $PINS A0=FE_OFN87_n875 A1=n882 B0=n984 B1=n1784 Y=n1344
XU1150 AO22X1TR $PINS A0=FE_OFN102_n876 A1=n882 B0=n986 B1=n1785 Y=n1345
XU1152 AO22X1TR $PINS A0=FE_OFN96_n877 A1=FE_OFN33_n882 B0=n988 B1=n1786
+ Y=n1346
XU1153 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__0_ B=pe_in_pk_wrb_addr__1_ C=n6
+ Y=n917
XU1154 AO22X1TR $PINS A0=n878 A1=FE_OFN33_n882 B0=n990 B1=n1787 Y=n1347
XU1156 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN58_n882 B0=n1009 B1=n1788
+ Y=n1348
XU1158 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN58_n882 B0=n1011 B1=n1789
+ Y=n1349
XU1159 OAI21X2TR $PINS A0=n879 A1=n915 B0=FE_OFN146_reset Y=n883
XU1160 AO22X1TR $PINS A0=n883 A1=FE_OFN58_n882 B0=n1013 B1=n1790 Y=n1350
XU1162 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN58_n882 B0=n1015 B1=n1791
+ Y=n1351
XU1163 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN58_n882 B0=n1017 B1=n1792
+ Y=n1352
XU1164 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN58_n882 B0=n1019 B1=n1793
+ Y=n1353
XU1165 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=pe_in_pk_wrb_addr__0_
+ C=pe_in_pk_wrb_addr__1_ Y=n927
XU1167 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN33_n882 B0=n997 B1=n1794
+ Y=n1354
XU1168 AO22X1TR $PINS A0=FE_OFN69_n894 A1=FE_OFN33_n882 B0=n999 B1=n1795
+ Y=n1355
XU1169 INVX2TR $PINS A=n895 Y=n948
XU1170 AO22X1TR $PINS A0=n895 A1=FE_OFN58_n882 B0=n948 B1=n1796 Y=n1356
XU1172 AO22X1TR $PINS A0=n1001 A1=FE_OFN58_n882 B0=FE_OFN50_n896 B1=n1797
+ Y=n1357
XU1173 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN33_n882 B0=n1003 B1=n1799
+ Y=n1358
XU1174 NAND2X2TR $PINS A=pe_in_pk_wrb__1_ B=n906 Y=n900
XU1175 OAI21X1TR $PINS A0=n913 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n901
XU1176 AO22X1TR $PINS A0=FE_OFN135_n901 A1=FE_OFN59_n882 B0=n954 B1=n1802
+ Y=n1360
XU1178 OAI21X1TR $PINS A0=n915 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n903
XU1179 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN59_n882 B0=n956 B1=n1804
+ Y=n1362
XU1180 INVX2TR $PINS A=n904 Y=n962
XU1181 AO22X1TR $PINS A0=n904 A1=FE_OFN59_n882 B0=n962 B1=n1805 Y=n1363
XU1182 INVX2TR $PINS A=n905 Y=n964
XU1183 AO22X1TR $PINS A0=n905 A1=FE_OFN59_n882 B0=n964 B1=n1806 Y=n1364
XU1185 AO22X1TR $PINS A0=FE_OFN110_n909 A1=n882 B0=FE_OFN53_n909 B1=n1808
+ Y=n1366
XU1186 AO22X1TR $PINS A0=n911 A1=FE_OFN58_n882 B0=n966 B1=n1809 Y=n1367
XU1187 AO22X1TR $PINS A0=n914 A1=FE_OFN58_n882 B0=FE_OFN82_n914 B1=n1810
+ Y=n1368
XU1188 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN58_n882 B0=n969 B1=n1811
+ Y=n1369
XU1189 OAI21X1TR $PINS A0=n917 A1=n907 B0=FE_OFN31_FE_DBTN3_reset Y=n918
XU1190 AO22X1TR $PINS A0=FE_OFN115_n918 A1=n882 B0=n972 B1=n1812 Y=n1370
XU1191 AO22X1TR $PINS A0=n919 A1=FE_OFN58_n882 B0=FE_OFN55_n919 B1=n1813
+ Y=n1371
XU1192 OAI21X1TR $PINS A0=n923 A1=n907 B0=FE_OFN31_FE_DBTN3_reset Y=n920
XU1193 AO22X1TR $PINS A0=FE_OFN74_n920 A1=FE_OFN58_n882 B0=n976 B1=n1814
+ Y=n1372
XU1194 AO22X1TR $PINS A0=FE_OFN91_n922 A1=FE_OFN33_n882 B0=n992 B1=n1815
+ Y=n1373
XU1195 AO22X1TR $PINS A0=n924 A1=FE_OFN33_n882 B0=n994 B1=n1816 Y=n1374
XU1197 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN59_n882 B0=n980 B1=n1818
+ Y=n1375
XU1199 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN59_n882 B0=n958 B1=n1820
+ Y=n1377
XU1200 INVX2TR $PINS A=n932 Y=n952
XU1201 AO22X1TR $PINS A0=n932 A1=FE_OFN59_n882 B0=n952 B1=n1821 Y=n1378
XU1202 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN59_n882 B0=n978 B1=n1823
+ Y=n1379
XU1203 AO22X1TR $PINS A0=FE_OFN87_n875 A1=n938 B0=n984 B1=n1824 Y=n1380
XU1204 AO22X1TR $PINS A0=FE_OFN99_n876 A1=FE_OFN35_n938 B0=n986 B1=n1825
+ Y=n1381
XU1205 AO22X1TR $PINS A0=FE_OFN96_n877 A1=FE_OFN56_n938 B0=n988 B1=n1826
+ Y=n1382
XU1206 AO22X1TR $PINS A0=n878 A1=FE_OFN56_n938 B0=n990 B1=n1827 Y=n1383
XU1207 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN57_n938 B0=n1009 B1=n1828
+ Y=n1384
XU1208 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN57_n938 B0=n1011 B1=n1829
+ Y=n1385
XU1209 AO22X1TR $PINS A0=n883 A1=FE_OFN57_n938 B0=n1013 B1=n1830 Y=n1386
XU1210 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN57_n938 B0=n1015 B1=n1831
+ Y=n1387
XU1211 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN57_n938 B0=n1017 B1=n1832
+ Y=n1388
XU1212 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN57_n938 B0=n1019 B1=n1833
+ Y=n1389
XU1213 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN56_n938 B0=n997 B1=n1834
+ Y=n1390
XU1214 AO22X1TR $PINS A0=FE_OFN71_n894 A1=FE_OFN56_n938 B0=n999 B1=n1835
+ Y=n1391
XU1215 AO22X1TR $PINS A0=n895 A1=FE_OFN57_n938 B0=n948 B1=n1836 Y=n1392
XU1216 AO22X1TR $PINS A0=n1001 A1=FE_OFN57_n938 B0=FE_OFN50_n896 B1=n1837
+ Y=n1393
XU1217 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN56_n938 B0=n1003 B1=n1839
+ Y=n1394
XU1218 AO22X1TR $PINS A0=FE_OFN131_n901 A1=FE_OFN57_n938 B0=n954 B1=n1842
+ Y=n1396
XU1219 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN35_n938 B0=n956 B1=n1844
+ Y=n1398
XU1220 AO22X1TR $PINS A0=n904 A1=FE_OFN35_n938 B0=n962 B1=n1845 Y=n1399
XU1221 AO22X1TR $PINS A0=n905 A1=FE_OFN35_n938 B0=n964 B1=n1846 Y=n1400
XU1222 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN35_n938 B0=FE_OFN53_n909
+ B1=n1848 Y=n1402
XU1223 AO22X1TR $PINS A0=n914 A1=FE_OFN57_n938 B0=FE_OFN82_n914 B1=n1850
+ Y=n1404
XU1224 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN35_n938 B0=n969 B1=n1851
+ Y=n1405
XU1225 AO22X1TR $PINS A0=FE_OFN114_n918 A1=FE_OFN35_n938 B0=n972 B1=n1852
+ Y=n1406
XU1226 AO22X1TR $PINS A0=n919 A1=FE_OFN35_n938 B0=FE_OFN55_n919 B1=n1853
+ Y=n1407
XU1227 AO22X1TR $PINS A0=FE_OFN74_n920 A1=FE_OFN35_n938 B0=n976 B1=n1854
+ Y=n1408
XU1228 AO22X1TR $PINS A0=FE_OFN91_n922 A1=FE_OFN56_n938 B0=n992 B1=n1855
+ Y=n1409
XU1229 AO22X1TR $PINS A0=n924 A1=FE_OFN56_n938 B0=n994 B1=n1856 Y=n1410
XU1230 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN35_n938 B0=n980 B1=n1858
+ Y=n1411
XU1231 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN35_n938 B0=n958 B1=n1860
+ Y=n1413
XU1232 AO22X1TR $PINS A0=n932 A1=FE_OFN57_n938 B0=n952 B1=n1861 Y=n1414
XU1233 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN35_n938 B0=n978 B1=n1863
+ Y=n1415
XU1234 AO22X1TR $PINS A0=FE_OFN87_n875 A1=n940 B0=n984 B1=n1864 Y=n1416
XU1235 AO22X1TR $PINS A0=FE_OFN102_n876 A1=n940 B0=n986 B1=n1865 Y=n1417
XU1236 AO22X1TR $PINS A0=FE_OFN96_n877 A1=FE_OFN36_n940 B0=n988 B1=n1866
+ Y=n1418
XU1237 AO22X1TR $PINS A0=n878 A1=FE_OFN36_n940 B0=n990 B1=n1867 Y=n1419
XU1238 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN37_n940 B0=n1009 B1=n1868
+ Y=n1420
XU1239 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN37_n940 B0=n1011 B1=n1869
+ Y=n1421
XU1240 AO22X1TR $PINS A0=n883 A1=FE_OFN37_n940 B0=n1013 B1=n1870 Y=n1422
XU1241 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN37_n940 B0=n1015 B1=n1871
+ Y=n1423
XU1242 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN37_n940 B0=n1017 B1=n1872
+ Y=n1424
XU1243 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN37_n940 B0=n1019 B1=n1873
+ Y=n1425
XU1244 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN36_n940 B0=n997 B1=n1874
+ Y=n1426
XU1245 AO22X1TR $PINS A0=FE_OFN69_n894 A1=FE_OFN36_n940 B0=n999 B1=n1875
+ Y=n1427
XU1246 AO22X1TR $PINS A0=n895 A1=FE_OFN37_n940 B0=n948 B1=n1876 Y=n1428
XU1247 AO22X1TR $PINS A0=FE_OFN73_n896 A1=FE_OFN37_n940 B0=FE_OFN50_n896
+ B1=n1877 Y=n1429
XU1248 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN36_n940 B0=n1003 B1=n1879
+ Y=n1430
XU1249 AO22X1TR $PINS A0=FE_OFN136_n901 A1=FE_OFN37_n940 B0=n954 B1=n1882
+ Y=n1432
XU1250 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN37_n940 B0=n956 B1=n1884
+ Y=n1434
XU1251 AO22X1TR $PINS A0=n904 A1=FE_OFN36_n940 B0=n962 B1=n1885 Y=n1435
XU1252 AO22X1TR $PINS A0=n905 A1=FE_OFN36_n940 B0=n964 B1=n1886 Y=n1436
XU1253 AO22X1TR $PINS A0=FE_OFN110_n909 A1=n940 B0=FE_OFN53_n909 B1=n1888
+ Y=n1438
XU1254 AO22X1TR $PINS A0=n914 A1=FE_OFN37_n940 B0=FE_OFN82_n914 B1=n1890
+ Y=n1440
XU1255 AO22X1TR $PINS A0=FE_OFN54_n916 A1=n940 B0=n969 B1=n1891 Y=n1441
XU1256 AO22X1TR $PINS A0=FE_OFN117_n918 A1=n940 B0=n972 B1=n1892 Y=n1442
XU1257 AO22X1TR $PINS A0=n919 A1=FE_OFN37_n940 B0=FE_OFN55_n919 B1=n1893
+ Y=n1443
XU1258 AO22X1TR $PINS A0=FE_OFN74_n920 A1=n940 B0=n976 B1=n1894 Y=n1444
XU1259 AO22X1TR $PINS A0=FE_OFN91_n922 A1=FE_OFN36_n940 B0=n992 B1=n1895
+ Y=n1445
XU1260 AO22X1TR $PINS A0=n924 A1=FE_OFN36_n940 B0=n994 B1=n1896 Y=n1446
XU1261 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN36_n940 B0=n980 B1=n1898
+ Y=n1447
XU1262 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN36_n940 B0=n958 B1=n1900
+ Y=n1449
XU1263 AO22X1TR $PINS A0=n932 A1=FE_OFN37_n940 B0=n952 B1=n1901 Y=n1450
XU1264 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN36_n940 B0=n978 B1=n1903
+ Y=n1451
XU1265 AO22X1TR $PINS A0=FE_OFN86_n875 A1=n941 B0=n984 B1=n1904 Y=n1452
XU1266 AO22X1TR $PINS A0=FE_OFN103_n876 A1=n941 B0=n986 B1=n1905 Y=n1453
XU1267 AO22X1TR $PINS A0=FE_OFN96_n877 A1=n941 B0=n988 B1=n1906 Y=n1454
XU1268 AO22X1TR $PINS A0=n878 A1=n941 B0=n990 B1=n1907 Y=n1455
XU1269 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN39_n941 B0=n1009 B1=n1908
+ Y=n1456
XU1270 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN39_n941 B0=n1011 B1=n1909
+ Y=n1457
XU1271 AO22X1TR $PINS A0=n883 A1=FE_OFN39_n941 B0=n1013 B1=n1910 Y=n1458
XU1272 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN39_n941 B0=n1015 B1=n1911
+ Y=n1459
XU1273 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN39_n941 B0=n1017 B1=n1912
+ Y=n1460
XU1274 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN39_n941 B0=n1019 B1=n1913
+ Y=n1461
XU1275 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN38_n941 B0=n997 B1=n1914
+ Y=n1462
XU1276 AO22X1TR $PINS A0=FE_OFN71_n894 A1=FE_OFN38_n941 B0=n999 B1=n1915
+ Y=n1463
XU1277 AO22X1TR $PINS A0=n895 A1=FE_OFN39_n941 B0=n948 B1=n1916 Y=n1464
XU1278 AO22X1TR $PINS A0=n1001 A1=FE_OFN39_n941 B0=FE_OFN50_n896 B1=n1917
+ Y=n1465
XU1279 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN38_n941 B0=n1003 B1=n1919
+ Y=n1466
XU1280 AO22X1TR $PINS A0=FE_OFN134_n901 A1=FE_OFN38_n941 B0=n954 B1=n1922
+ Y=n1468
XU1281 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN38_n941 B0=n956 B1=n1924
+ Y=n1470
XU1282 AO22X1TR $PINS A0=n904 A1=FE_OFN38_n941 B0=n962 B1=n1925 Y=n1471
XU1283 AO22X1TR $PINS A0=n905 A1=FE_OFN38_n941 B0=n964 B1=n1926 Y=n1472
XU1284 AO22X1TR $PINS A0=FE_OFN112_n909 A1=FE_OFN39_n941 B0=FE_OFN53_n909
+ B1=n1928 Y=n1474
XU1285 AO22X1TR $PINS A0=n914 A1=FE_OFN39_n941 B0=FE_OFN82_n914 B1=n1930
+ Y=n1476
XU1286 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN39_n941 B0=n969 B1=n1931
+ Y=n1477
XU1287 AO22X1TR $PINS A0=FE_OFN118_n918 A1=FE_OFN39_n941 B0=n972 B1=n1932
+ Y=n1478
XU1288 AO22X1TR $PINS A0=FE_OFN80_n919 A1=FE_OFN39_n941 B0=FE_OFN55_n919
+ B1=n1933 Y=n1479
XU1289 AO22X1TR $PINS A0=FE_OFN76_n920 A1=FE_OFN39_n941 B0=n976 B1=n1934
+ Y=n1480
XU1290 AO22X1TR $PINS A0=FE_OFN91_n922 A1=FE_OFN38_n941 B0=n992 B1=n1935
+ Y=n1481
XU1291 AO22X1TR $PINS A0=n924 A1=FE_OFN38_n941 B0=n994 B1=n1936 Y=n1482
XU1292 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN38_n941 B0=n980 B1=n1938
+ Y=n1483
XU1293 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN38_n941 B0=n958 B1=n1940
+ Y=n1485
XU1294 AO22X1TR $PINS A0=n932 A1=FE_OFN38_n941 B0=n952 B1=n1941 Y=n1486
XU1295 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN38_n941 B0=n978 B1=n1943
+ Y=n1487
XU1296 AO22X1TR $PINS A0=FE_OFN87_n875 A1=n944 B0=n984 B1=n1944 Y=n1488
XU1297 AO22X1TR $PINS A0=FE_OFN99_n876 A1=n944 B0=n986 B1=n1945 Y=n1489
XU1298 AO22X1TR $PINS A0=FE_OFN96_n877 A1=n944 B0=n988 B1=n1946 Y=n1490
XU1299 AO22X1TR $PINS A0=n878 A1=n944 B0=n990 B1=n1947 Y=n1491
XU1300 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN41_n944 B0=n1009 B1=n1948
+ Y=n1492
XU1301 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN41_n944 B0=n1011 B1=n1949
+ Y=n1493
XU1302 AO22X1TR $PINS A0=n883 A1=FE_OFN41_n944 B0=n1013 B1=n1950 Y=n1494
XU1303 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN41_n944 B0=n1015 B1=n1951
+ Y=n1495
XU1304 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN41_n944 B0=n1017 B1=n1952
+ Y=n1496
XU1305 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN41_n944 B0=n1019 B1=n1953
+ Y=n1497
XU1306 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN40_n944 B0=n997 B1=n1954
+ Y=n1498
XU1307 AO22X1TR $PINS A0=FE_OFN69_n894 A1=FE_OFN40_n944 B0=n999 B1=n1955
+ Y=n1499
XU1308 AO22X1TR $PINS A0=n895 A1=FE_OFN41_n944 B0=n948 B1=n1956 Y=n1500
XU1309 AO22X1TR $PINS A0=n1001 A1=FE_OFN41_n944 B0=FE_OFN50_n896 B1=n1957
+ Y=n1501
XU1310 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN40_n944 B0=n1003 B1=n1959
+ Y=n1502
XU1311 AO22X1TR $PINS A0=FE_OFN137_n901 A1=FE_OFN40_n944 B0=n954 B1=n1962
+ Y=n1504
XU1312 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN40_n944 B0=n956 B1=n1964
+ Y=n1506
XU1313 AO22X1TR $PINS A0=n904 A1=FE_OFN40_n944 B0=n962 B1=n1965 Y=n1507
XU1314 AO22X1TR $PINS A0=n905 A1=FE_OFN40_n944 B0=n964 B1=n1966 Y=n1508
XU1315 AO22X1TR $PINS A0=FE_OFN113_n909 A1=FE_OFN41_n944 B0=FE_OFN53_n909
+ B1=n1968 Y=n1510
XU1316 AO22X1TR $PINS A0=n914 A1=FE_OFN41_n944 B0=FE_OFN82_n914 B1=n1970
+ Y=n1512
XU1317 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN41_n944 B0=n969 B1=n1971
+ Y=n1513
XU1318 AO22X1TR $PINS A0=FE_OFN118_n918 A1=FE_OFN41_n944 B0=n972 B1=n1972
+ Y=n1514
XU1319 AO22X1TR $PINS A0=FE_OFN80_n919 A1=FE_OFN41_n944 B0=FE_OFN55_n919
+ B1=n1973 Y=n1515
XU1320 AO22X1TR $PINS A0=FE_OFN76_n920 A1=FE_OFN41_n944 B0=n976 B1=n1974
+ Y=n1516
XU1321 AO22X1TR $PINS A0=FE_OFN91_n922 A1=FE_OFN40_n944 B0=n992 B1=n1975
+ Y=n1517
XU1322 AO22X1TR $PINS A0=n924 A1=FE_OFN40_n944 B0=n994 B1=n1976 Y=n1518
XU1323 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN40_n944 B0=n980 B1=n1978
+ Y=n1519
XU1324 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN40_n944 B0=n958 B1=n1980
+ Y=n1521
XU1325 AO22X1TR $PINS A0=n932 A1=FE_OFN40_n944 B0=n952 B1=n1981 Y=n1522
XU1326 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN40_n944 B0=n978 B1=n1983
+ Y=n1523
XU1327 AO22X1TR $PINS A0=FE_OFN86_n875 A1=n945 B0=n984 B1=n1984 Y=n1524
XU1328 AO22X1TR $PINS A0=FE_OFN101_n876 A1=n945 B0=n986 B1=n1985 Y=n1525
XU1329 AO22X1TR $PINS A0=FE_OFN96_n877 A1=n945 B0=n988 B1=n1986 Y=n1526
XU1330 AO22X1TR $PINS A0=n878 A1=n945 B0=n990 B1=n1987 Y=n1527
XU1331 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN42_n945 B0=n1009 B1=n1988
+ Y=n1528
XU1332 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN42_n945 B0=n1011 B1=n1989
+ Y=n1529
XU1333 AO22X1TR $PINS A0=n883 A1=FE_OFN42_n945 B0=n1013 B1=n1990 Y=n1530
XU1334 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN42_n945 B0=n1015 B1=n1991
+ Y=n1531
XU1335 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN42_n945 B0=n1017 B1=n1992
+ Y=n1532
XU1336 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN42_n945 B0=n1019 B1=n1993
+ Y=n1533
XU1337 AO22X1TR $PINS A0=FE_OFN108_n890 A1=FE_OFN43_n945 B0=n997 B1=n1994
+ Y=n1534
XU1338 AO22X1TR $PINS A0=FE_OFN71_n894 A1=FE_OFN43_n945 B0=n999 B1=n1995
+ Y=n1535
XU1339 AO22X1TR $PINS A0=n895 A1=FE_OFN42_n945 B0=n948 B1=n1996 Y=n1536
XU1340 AO22X1TR $PINS A0=FE_OFN73_n896 A1=FE_OFN42_n945 B0=FE_OFN50_n896
+ B1=n1997 Y=n1537
XU1341 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN43_n945 B0=n1003 B1=n1999
+ Y=n1538
XU1342 AO22X1TR $PINS A0=FE_OFN133_n901 A1=FE_OFN43_n945 B0=n954 B1=n2002
+ Y=n1540
XU1343 AO22X1TR $PINS A0=FE_OFN139_n903 A1=FE_OFN43_n945 B0=n956 B1=n2004
+ Y=n1542
XU1344 AO22X1TR $PINS A0=n904 A1=FE_OFN43_n945 B0=n962 B1=n2005 Y=n1543
XU1345 AO22X1TR $PINS A0=n905 A1=FE_OFN43_n945 B0=n964 B1=n2006 Y=n1544
XU1346 AO22X1TR $PINS A0=FE_OFN112_n909 A1=FE_OFN42_n945 B0=FE_OFN53_n909
+ B1=n2008 Y=n1546
XU1347 AO22X1TR $PINS A0=n914 A1=FE_OFN42_n945 B0=FE_OFN82_n914 B1=n2010
+ Y=n1548
XU1348 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN42_n945 B0=n969 B1=n2011
+ Y=n1549
XU1349 AO22X1TR $PINS A0=FE_OFN118_n918 A1=FE_OFN42_n945 B0=n972 B1=n2012
+ Y=n1550
XU1350 AO22X1TR $PINS A0=n919 A1=FE_OFN42_n945 B0=FE_OFN55_n919 B1=n2013
+ Y=n1551
XU1351 AO22X1TR $PINS A0=FE_OFN76_n920 A1=FE_OFN42_n945 B0=n976 B1=n2014
+ Y=n1552
XU1352 AO22X1TR $PINS A0=FE_OFN93_n922 A1=FE_OFN43_n945 B0=n992 B1=n2015
+ Y=n1553
XU1353 AO22X1TR $PINS A0=n924 A1=FE_OFN43_n945 B0=n994 B1=n2016 Y=n1554
XU1354 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN43_n945 B0=n980 B1=n2018
+ Y=n1555
XU1355 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN43_n945 B0=n958 B1=n2020
+ Y=n1557
XU1356 AO22X1TR $PINS A0=n932 A1=FE_OFN43_n945 B0=n952 B1=n2021 Y=n1558
XU1357 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN43_n945 B0=n978 B1=n2023
+ Y=n1559
XU1358 AO22X1TR $PINS A0=FE_OFN84_n875 A1=n946 B0=n984 B1=n2024 Y=n1560
XU1359 AO22X1TR $PINS A0=FE_OFN100_n876 A1=n946 B0=n986 B1=n2025 Y=n1561
XU1360 AO22X1TR $PINS A0=n877 A1=n946 B0=n988 B1=n2026 Y=n1562
XU1361 AO22X1TR $PINS A0=n878 A1=n946 B0=n990 B1=n2027 Y=n1563
XU1362 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN45_n946 B0=n1009 B1=n2028
+ Y=n1564
XU1363 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN45_n946 B0=n1011 B1=n2029
+ Y=n1565
XU1364 AO22X1TR $PINS A0=n883 A1=FE_OFN45_n946 B0=n1013 B1=n2030 Y=n1566
XU1365 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN45_n946 B0=n1015 B1=n2031
+ Y=n1567
XU1366 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN45_n946 B0=n1017 B1=n2032
+ Y=n1568
XU1367 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN45_n946 B0=n1019 B1=n2033
+ Y=n1569
XU1368 AO22X1TR $PINS A0=FE_OFN107_n890 A1=FE_OFN44_n946 B0=n997 B1=n2034
+ Y=n1570
XU1369 AO22X1TR $PINS A0=FE_OFN69_n894 A1=FE_OFN44_n946 B0=n999 B1=n2035
+ Y=n1571
XU1370 AO22X1TR $PINS A0=n895 A1=FE_OFN45_n946 B0=n948 B1=n2036 Y=n1572
XU1371 AO22X1TR $PINS A0=n1001 A1=FE_OFN45_n946 B0=FE_OFN50_n896 B1=n2037
+ Y=n1573
XU1372 AO22X1TR $PINS A0=FE_OFN68_n897 A1=FE_OFN44_n946 B0=n1003 B1=n2039
+ Y=n1574
XU1373 AO22X1TR $PINS A0=FE_OFN131_n901 A1=FE_OFN44_n946 B0=n954 B1=n2042
+ Y=n1576
XU1374 AO22X1TR $PINS A0=FE_OFN141_n903 A1=FE_OFN44_n946 B0=n956 B1=n2044
+ Y=n1578
XU1375 AO22X1TR $PINS A0=n904 A1=FE_OFN44_n946 B0=n962 B1=n2045 Y=n1579
XU1376 AO22X1TR $PINS A0=n905 A1=FE_OFN44_n946 B0=n964 B1=n2046 Y=n1580
XU1377 AO22X1TR $PINS A0=FE_OFN110_n909 A1=FE_OFN45_n946 B0=FE_OFN53_n909
+ B1=n2048 Y=n1582
XU1378 AO22X1TR $PINS A0=n914 A1=FE_OFN45_n946 B0=FE_OFN82_n914 B1=n2050
+ Y=n1584
XU1379 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN45_n946 B0=n969 B1=n2051
+ Y=n1585
XU1380 AO22X1TR $PINS A0=FE_OFN117_n918 A1=FE_OFN45_n946 B0=n972 B1=n2052
+ Y=n1586
XU1381 AO22X1TR $PINS A0=n919 A1=FE_OFN45_n946 B0=FE_OFN55_n919 B1=n2053
+ Y=n1587
XU1382 AO22X1TR $PINS A0=FE_OFN76_n920 A1=FE_OFN45_n946 B0=n976 B1=n2054
+ Y=n1588
XU1383 AO22X1TR $PINS A0=FE_OFN92_n922 A1=FE_OFN44_n946 B0=n992 B1=n2055
+ Y=n1589
XU1384 AO22X1TR $PINS A0=n924 A1=FE_OFN44_n946 B0=n994 B1=n2056 Y=n1590
XU1385 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN44_n946 B0=n980 B1=n2058
+ Y=n1591
XU1386 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN44_n946 B0=n958 B1=n2060
+ Y=n1593
XU1387 AO22X1TR $PINS A0=n932 A1=FE_OFN44_n946 B0=n952 B1=n2061 Y=n1594
XU1388 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN44_n946 B0=n978 B1=n2063
+ Y=n1595
XU1389 AO22X1TR $PINS A0=FE_OFN85_n875 A1=FE_OFN46_n947 B0=n984 B1=n2064
+ Y=n1596
XU1390 AO22X1TR $PINS A0=FE_OFN98_n876 A1=FE_OFN46_n947 B0=n986 B1=n2065
+ Y=n1597
XU1391 AO22X1TR $PINS A0=n877 A1=FE_OFN46_n947 B0=n988 B1=n2066 Y=n1598
XU1392 AO22X1TR $PINS A0=n878 A1=FE_OFN46_n947 B0=n990 B1=n2067 Y=n1599
XU1393 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN47_n947 B0=n1009 B1=n2068
+ Y=n1600
XU1394 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN47_n947 B0=n1011 B1=n2069
+ Y=n1601
XU1395 AO22X1TR $PINS A0=n883 A1=FE_OFN47_n947 B0=n1013 B1=n2070 Y=n1602
XU1396 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN47_n947 B0=n1015 B1=n2071
+ Y=n1603
XU1397 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN47_n947 B0=n1017 B1=n2072
+ Y=n1604
XU1398 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN47_n947 B0=n1019 B1=n2073
+ Y=n1605
XU1399 AO22X1TR $PINS A0=FE_OFN108_n890 A1=n947 B0=n997 B1=n2074 Y=n1606
XU1400 AO22X1TR $PINS A0=FE_OFN70_n894 A1=n947 B0=n999 B1=n2075 Y=n1607
XU1401 AO22X1TR $PINS A0=n895 A1=FE_OFN47_n947 B0=n948 B1=n2076 Y=n1608
XU1402 AO22X1TR $PINS A0=n1001 A1=FE_OFN47_n947 B0=FE_OFN50_n896 B1=n2077
+ Y=n1609
XU1403 AO22X1TR $PINS A0=FE_OFN67_n897 A1=n947 B0=n1003 B1=n2079 Y=n1610
XU1404 AO22X1TR $PINS A0=FE_OFN132_n901 A1=FE_OFN61_n947 B0=n954 B1=n2082
+ Y=n1612
XU1405 AO22X1TR $PINS A0=FE_OFN140_n903 A1=FE_OFN61_n947 B0=n956 B1=n2084
+ Y=n1614
XU1406 AO22X1TR $PINS A0=n904 A1=FE_OFN47_n947 B0=n962 B1=n2085 Y=n1615
XU1407 AO22X1TR $PINS A0=n905 A1=FE_OFN61_n947 B0=n964 B1=n2086 Y=n1616
XU1408 AO22X1TR $PINS A0=FE_OFN111_n909 A1=FE_OFN46_n947 B0=FE_OFN53_n909
+ B1=n2088 Y=n1618
XU1409 AO22X1TR $PINS A0=n914 A1=FE_OFN47_n947 B0=FE_OFN82_n914 B1=n2090
+ Y=n1620
XU1410 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN46_n947 B0=n969 B1=n2091
+ Y=n1621
XU1411 AO22X1TR $PINS A0=FE_OFN116_n918 A1=FE_OFN46_n947 B0=n972 B1=n2092
+ Y=n1622
XU1412 AO22X1TR $PINS A0=FE_OFN80_n919 A1=FE_OFN46_n947 B0=FE_OFN55_n919
+ B1=n2093 Y=n1623
XU1413 AO22X1TR $PINS A0=FE_OFN75_n920 A1=FE_OFN46_n947 B0=n976 B1=n2094
+ Y=n1624
XU1414 AO22X1TR $PINS A0=FE_OFN90_n922 A1=FE_OFN46_n947 B0=n992 B1=n2095
+ Y=n1625
XU1415 AO22X1TR $PINS A0=n924 A1=n947 B0=n994 B1=n2096 Y=n1626
XU1416 AO22X1TR $PINS A0=FE_OFN77_n926 A1=n947 B0=n980 B1=n2098 Y=n1627
XU1417 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN61_n947 B0=n958 B1=n2100
+ Y=n1629
XU1418 AO22X1TR $PINS A0=n932 A1=FE_OFN61_n947 B0=n952 B1=n2101 Y=n1630
XU1419 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN61_n947 B0=n978 B1=n2103
+ Y=n1631
XU1420 AO22X1TR $PINS A0=n895 A1=FE_OFN145_reset B0=n948 B1=n2104 Y=n1632
XU1421 AO22X1TR $PINS A0=n932 A1=FE_OFN146_reset B0=n952 B1=n2106 Y=n1634
XU1422 AO22X1TR $PINS A0=FE_OFN131_n901 A1=FE_OFN146_reset B0=n954 B1=n2108
+ Y=n1635
XU1423 AO22X1TR $PINS A0=FE_OFN138_n903 A1=FE_OFN29_FE_DBTN3_reset B0=n956
+ B1=n2109 Y=n1636
XU1424 AO22X1TR $PINS A0=FE_OFN65_n930 A1=FE_OFN29_FE_DBTN3_reset B0=n958
+ B1=n2110 Y=n1637
XU1425 AO22X1TR $PINS A0=n904 A1=FE_OFN29_FE_DBTN3_reset B0=n962 B1=n2112
+ Y=n1639
XU1426 AO22X1TR $PINS A0=n905 A1=FE_OFN29_FE_DBTN3_reset B0=n964 B1=n2113
+ Y=n1640
XU1427 AO22X1TR $PINS A0=n914 A1=FE_OFN1_reset B0=FE_OFN82_n914 B1=n2115
+ Y=n1642
XU1428 AO22X1TR $PINS A0=FE_OFN54_n916 A1=FE_OFN1_reset B0=n969 B1=n2116
+ Y=n1643
XU1429 AO22X1TR $PINS A0=FE_OFN114_n918 A1=FE_OFN1_reset B0=n972 B1=n2117
+ Y=n1644
XU1430 AO22X1TR $PINS A0=n919 A1=FE_OFN1_reset B0=FE_OFN55_n919 B1=n2118
+ Y=n1645
XU1431 AO22X1TR $PINS A0=FE_OFN74_n920 A1=FE_OFN1_reset B0=n976 B1=n2119
+ Y=n1646
XU1432 AO22X1TR $PINS A0=FE_OFN95_n935 A1=FE_OFN144_reset B0=n978 B1=n2120
+ Y=n1647
XU1433 AO22X1TR $PINS A0=FE_OFN77_n926 A1=FE_OFN31_FE_DBTN3_reset B0=n980
+ B1=n2121 Y=n1648
XU1434 AO22X1TR $PINS A0=n982 A1=FE_OFN30_FE_DBTN3_reset B0=FE_OFN53_n909
+ B1=n2122 Y=n1649
XU1435 AO22X1TR $PINS A0=FE_OFN83_n875 A1=FE_OFN30_FE_DBTN3_reset B0=n984
+ B1=n2123 Y=n1650
XU1436 AO22X1TR $PINS A0=FE_OFN97_n876 A1=FE_OFN30_FE_DBTN3_reset B0=n986
+ B1=n2124 Y=n1651
XU1437 AO22X1TR $PINS A0=n877 A1=FE_OFN30_FE_DBTN3_reset B0=n988 B1=n2125
+ Y=n1652
XU1438 AO22X1TR $PINS A0=n878 A1=FE_OFN30_FE_DBTN3_reset B0=n990 B1=n2126
+ Y=n1653
XU1439 AO22X1TR $PINS A0=FE_OFN89_n922 A1=FE_OFN31_FE_DBTN3_reset B0=n992
+ B1=n2127 Y=n1654
XU1440 AO22X1TR $PINS A0=n924 A1=FE_OFN31_FE_DBTN3_reset B0=n994 B1=n2128
+ Y=n1655
XU1441 AO22X1TR $PINS A0=FE_OFN106_n890 A1=FE_OFN31_FE_DBTN3_reset B0=n997
+ B1=n2129 Y=n1656
XU1442 AO22X1TR $PINS A0=FE_OFN69_n894 A1=FE_OFN31_FE_DBTN3_reset B0=n999
+ B1=n2130 Y=n1657
XU1443 AO22X1TR $PINS A0=FE_OFN72_n896 A1=FE_OFN145_reset B0=FE_OFN50_n896
+ B1=n2131 Y=n1658
XU1444 AO22X1TR $PINS A0=FE_OFN66_n897 A1=FE_OFN31_FE_DBTN3_reset B0=n1003
+ B1=n2132 Y=n1659
XU1445 AO22X1TR $PINS A0=FE_OFN48_n880 A1=FE_OFN145_reset B0=n1009 B1=n2135
+ Y=n1662
XU1446 AO22X1TR $PINS A0=FE_OFN49_n881 A1=FE_OFN145_reset B0=n1011 B1=n2136
+ Y=n1663
XU1447 AO22X1TR $PINS A0=n883 A1=FE_OFN145_reset B0=n1013 B1=n2137 Y=n1664
XU1448 AO22X1TR $PINS A0=FE_OFN122_n884 A1=FE_OFN145_reset B0=n1015 B1=n2138
+ Y=n1665
XU1449 AO22X1TR $PINS A0=FE_OFN63_n886 A1=FE_OFN146_reset B0=n1017 B1=n2139
+ Y=n1666
XU1450 AO22X1TR $PINS A0=FE_OFN62_n887 A1=FE_OFN146_reset B0=n1019 B1=n2140
+ Y=n1667
XU1451 NAND2X1TR $PINS A=n1021 B=n1026 Y=n1022
XU1452 XNOR2X1TR $PINS A=n1025 B=n1022 Y=n1023
XU1453 NAND2X1TR $PINS A=pe_out_pk_data__2_ B=n744 Y=n1024
XU1454 OAI2BB2XLTR $PINS A0N=n745 A1N=n2141 B0=n1024 B1=n745 Y=n1668
XU1455 CLKINVX2TR $PINS A=n1025 Y=n1028
XU1456 OAI21X1TR $PINS A0=n1028 A1=n1027 B0=n1026 Y=n1033
XU1457 NAND2X1TR $PINS A=n1031 B=n1030 Y=n1032
XU1458 XNOR2X1TR $PINS A=n1033 B=n1032 Y=n1034
XU1459 AND2X2TR $PINS A=n1034 B=FE_OFN26_FE_DBTN3_reset Y=pe_out_pk_data__3_
XU1460 NAND2X1TR $PINS A=pe_out_pk_data__3_ B=n744 Y=n1035
XU1461 OAI2BB2XLTR $PINS A0N=n745 A1N=n2142 B0=n1035 B1=n745 Y=n1669
XU1462 NAND2X1TR $PINS A=n1037 B=n1036 Y=n1038
XU1463 XNOR2X1TR $PINS A=n1039 B=n1038 Y=n1040
XU1464 AND2X2TR $PINS A=n1040 B=FE_OFN1_reset Y=pe_out_pk_data__5_
XU1465 NAND2X1TR $PINS A=pe_out_pk_data__5_ B=n744 Y=n1042
XU1466 OAI2BB2XLTR $PINS A0N=n745 A1N=n2143 B0=n1042 B1=n745 Y=n1670
XU1467 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2127 B0=n154 B1=n2128 Y=n1046
XU1468 AOI22X1TR $PINS A0=n155 A1=n2126 B0=n156 B1=n2125 Y=n1045
XU1469 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n2123 B0=FE_OFN8_n60 B1=n2124
+ Y=n1044
XU1470 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2129 B0=FE_OFN10_n64 B1=n2130
+ Y=n1043
XU1471 NAND4X1TR $PINS A=n1046 B=n1045 C=n1044 D=n1043 Y=n1047
XU1472 AND2X2TR $PINS A=n1048 B=n1047 Y=n2167
XU1473 NAND2X1TR $PINS A=n1050 B=n1049 Y=PE_top0_DP_OP_17J1_122_4844_n25
XU1474 NAND2X1TR $PINS A=n1054 B=n1053 Y=PE_top0_DP_OP_17J1_122_4844_n35
XU1475 NAND2X1TR $PINS A=n1056 B=n1055 Y=n1058
XU1476 XNOR2X1TR $PINS A=n1058 B=n1057 Y=PE_top0_adder0_out_int2<0>
XU1477 NAND2X1TR $PINS A=n1060 B=n1059 Y=n1062
XU1478 XNOR2X1TR $PINS A=n1062 B=n1061 Y=n1063
XU1479 AND2X2TR $PINS A=n1063 B=FE_OFN143_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_MULT_single0_out1_0_
XU1480 NAND2X1TR $PINS A=n1065 B=n1064 Y=n1067
XU1481 XNOR2X1TR $PINS A=n1067 B=n1066 Y=n1068
XU1482 AND2X2TR $PINS A=n1068 B=FE_OFN31_FE_DBTN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_MULT_single0_out1_0_
XU1483 NAND2X1TR $PINS A=n1070 B=n1069 Y=n1072
XU1484 XNOR2X1TR $PINS A=n1072 B=n1071 Y=n1074
XU1485 NOR2BX1TR $PINS AN=n1720 B=FE_OFN28_FE_DBTN3_reset Y=PE_top0_OUT_ADD<0>
XU1486 NAND2X1TR $PINS A=n1081 B=n1718 Y=n1082
XU1487 XOR2X1TR $PINS A=n1082 B=n1084 Y=n1083
XU1488 OAI21X1TR $PINS A0=n1084 A1=n1717 B0=n1718 Y=n1087
XU1489 NAND2X1TR $PINS A=n1085 B=n1716 Y=n1086
XU1490 XNOR2X1TR $PINS A=n1087 B=n1086 Y=n1088
XU1491 NAND2X1TR $PINS A=n1089 B=n1714 Y=n1090
XU1492 XOR2X1TR $PINS A=n1100 B=n1090 Y=n1091
XU1493 NOR2BX1TR $PINS AN=n1091 B=FE_OFN28_FE_DBTN3_reset Y=PE_top0_OUT_ADD<4>
XU1494 OAI21X1TR $PINS A0=n1100 A1=n1713 B0=n1714 Y=n1094
XU1495 NAND2X1TR $PINS A=n1092 B=n1712 Y=n1093
XU1496 XNOR2X1TR $PINS A=n1094 B=n1093 Y=n1095
XU1497 NOR2BX1TR $PINS AN=n1095 B=FE_OFN28_FE_DBTN3_reset Y=PE_top0_OUT_ADD<5>
XU1498 OAI21X1TR $PINS A0=n1100 A1=n1099 B0=n1098 Y=n1102
XU1499 NAND2X1TR $PINS A=n1783 B=n1710 Y=n1101
XU1500 XNOR2X1TR $PINS A=n1102 B=n1101 Y=n1103
XU1501 NOR2BX1TR $PINS AN=n1103 B=FE_OFN28_FE_DBTN3_reset Y=PE_top0_OUT_ADD<6>
XU1502 NOR2BX1TR $PINS AN=pe_in_pk_A__0__7_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<7>
XU1503 NOR2BX1TR $PINS AN=pe_in_pk_A__0__6_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<6>
XU1504 NOR2BX1TR $PINS AN=pe_in_pk_A__0__5_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<5>
XU1505 NOR2BX1TR $PINS AN=pe_in_pk_A__0__4_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<4>
XU1506 NOR2BX1TR $PINS AN=pe_in_pk_A__0__3_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<3>
XU1507 NOR2BX1TR $PINS AN=pe_in_pk_A__0__2_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<2>
XU1508 NOR2BX1TR $PINS AN=pe_in_pk_A__0__1_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<1>
XU1509 NOR2BX1TR $PINS AN=pe_in_pk_A__0__0_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_0__buffer_mult0_mult_A<0>
XU1510 NOR2BX1TR $PINS AN=pe_in_pk_A__3__7_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<7>
XU1511 NOR2BX1TR $PINS AN=pe_in_pk_A__3__6_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<6>
XU1512 NOR2BX1TR $PINS AN=pe_in_pk_A__3__5_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<5>
XU1513 NOR2BX1TR $PINS AN=pe_in_pk_A__3__4_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<4>
XU1514 NOR2BX1TR $PINS AN=pe_in_pk_A__3__3_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<3>
XU1515 NOR2BX1TR $PINS AN=pe_in_pk_A__3__2_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<2>
XU1516 NOR2BX1TR $PINS AN=pe_in_pk_A__3__1_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<1>
XU1517 NOR2BX1TR $PINS AN=pe_in_pk_A__3__0_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_3__buffer_mult0_mult_A<0>
XU1518 NOR2BX1TR $PINS AN=pe_in_pk_A__2__7_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<7>
XU1519 NOR2BX1TR $PINS AN=pe_in_pk_A__2__6_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<6>
XU1520 NOR2BX1TR $PINS AN=pe_in_pk_A__2__5_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<5>
XU1521 NOR2BX1TR $PINS AN=pe_in_pk_A__2__4_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<4>
XU1522 NOR2BX1TR $PINS AN=pe_in_pk_A__2__3_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<3>
XU1523 NOR2BX1TR $PINS AN=pe_in_pk_A__2__2_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<2>
XU1524 NOR2BX1TR $PINS AN=pe_in_pk_A__2__1_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<1>
XU1525 NOR2BX1TR $PINS AN=pe_in_pk_A__2__0_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<0>
XU1526 NOR2BX1TR $PINS AN=pe_in_pk_A__1__7_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<7>
XU1527 NOR2BX1TR $PINS AN=pe_in_pk_A__1__6_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<6>
XU1528 NOR2BX1TR $PINS AN=pe_in_pk_A__1__5_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<5>
XU1529 NOR2BX1TR $PINS AN=pe_in_pk_A__1__4_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<4>
XU1530 NOR2BX1TR $PINS AN=pe_in_pk_A__1__3_ B=FE_OFN3_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<3>
XU1531 NOR2BX1TR $PINS AN=pe_in_pk_A__1__2_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<2>
XU1532 NOR2BX1TR $PINS AN=pe_in_pk_A__1__1_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<1>
XU1533 NOR2BX1TR $PINS AN=pe_in_pk_A__1__0_ B=FE_OFN2_reset
+ Y=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<0>
XU1534 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1805 B0=FE_OFN16_n154 B1=n1806
+ Y=n1110
XU1535 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n1803 B0=FE_OFN23_n156 B1=n1804
+ Y=n1109
XU1536 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1821 B0=FE_OFN7_n60 B1=n1802
+ Y=n1108
XU1537 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n1819 B0=FE_OFN9_n64 B1=n1820
+ Y=n1107
XU1538 NAND4X1TR $PINS A=n1110 B=n1109 C=n1108 D=n1107 Y=n2148
XU1539 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1845 B0=FE_OFN16_n154 B1=n1846
+ Y=n1114
XU1540 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n1843 B0=FE_OFN23_n156 B1=n1844
+ Y=n1113
XU1541 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1861 B0=FE_OFN7_n60 B1=n1842
+ Y=n1112
XU1542 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n1859 B0=FE_OFN9_n64 B1=n1860
+ Y=n1111
XU1543 NAND4X1TR $PINS A=n1114 B=n1113 C=n1112 D=n1111 Y=n2150
XU1544 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1885 B0=FE_OFN16_n154 B1=n1886
+ Y=n1118
XU1545 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n1883 B0=FE_OFN23_n156 B1=n1884
+ Y=n1117
XU1546 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1901 B0=FE_OFN7_n60 B1=n1882
+ Y=n1116
XU1547 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n1899 B0=FE_OFN9_n64 B1=n1900
+ Y=n1115
XU1548 NAND4X1TR $PINS A=n1118 B=n1117 C=n1116 D=n1115 Y=n2151
XU1549 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1925 B0=FE_OFN16_n154 B1=n1926
+ Y=n1122
XU1550 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n1923 B0=FE_OFN23_n156 B1=n1924
+ Y=n1121
XU1551 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1941 B0=FE_OFN7_n60 B1=n1922
+ Y=n1120
XU1552 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n1939 B0=FE_OFN9_n64 B1=n1940
+ Y=n1119
XU1553 NAND4X1TR $PINS A=n1122 B=n1121 C=n1120 D=n1119 Y=n2152
XU1554 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1965 B0=FE_OFN16_n154 B1=n1966
+ Y=n1126
XU1555 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n1963 B0=FE_OFN23_n156 B1=n1964
+ Y=n1125
XU1556 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1981 B0=FE_OFN7_n60 B1=n1962
+ Y=n1124
XU1557 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n1979 B0=FE_OFN9_n64 B1=n1980
+ Y=n1123
XU1558 NAND4X1TR $PINS A=n1126 B=n1125 C=n1124 D=n1123 Y=n2153
XU1559 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2005 B0=FE_OFN16_n154 B1=n2006
+ Y=n1130
XU1560 AOI22X1TR $PINS A0=FE_OFN64_n155 A1=n2003 B0=FE_OFN23_n156 B1=n2004
+ Y=n1129
XU1561 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2021 B0=FE_OFN7_n60 B1=n2002
+ Y=n1128
XU1562 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n2019 B0=FE_OFN9_n64 B1=n2020
+ Y=n1127
XU1563 NAND4X1TR $PINS A=n1130 B=n1129 C=n1128 D=n1127 Y=n2154
XU1564 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2045 B0=FE_OFN16_n154 B1=n2046
+ Y=n1134
XU1565 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n2043 B0=FE_OFN60_n156 B1=n2044
+ Y=n1133
XU1566 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2061 B0=FE_OFN7_n60 B1=n2042
+ Y=n1132
XU1567 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n2059 B0=FE_OFN9_n64 B1=n2060
+ Y=n1131
XU1568 NAND4X1TR $PINS A=n1134 B=n1133 C=n1132 D=n1131 Y=n2155
XU1569 NAND3X1TR $PINS A=pe_in_pk_rdb_addr__3_ B=FE_OFN9_n64
+ C=FE_OFN31_FE_DBTN3_reset Y=n1244
XU1570 NOR2BX1TR $PINS AN=n2120 B=n1244 Y=n2149
XU1571 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n2085 B0=FE_OFN16_n154 B1=n2086
+ Y=n1138
XU1572 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n2083 B0=FE_OFN60_n156 B1=n2084
+ Y=n1137
XU1573 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2101 B0=FE_OFN7_n60 B1=n2082
+ Y=n1136
XU1574 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n2099 B0=FE_OFN9_n64 B1=n2100
+ Y=n1135
XU1575 NAND4X1TR $PINS A=n1138 B=n1137 C=n1136 D=n1135 Y=n2156
XU1576 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1813 B0=FE_OFN17_n154 B1=n1814
+ Y=n1142
XU1577 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n1812 B0=FE_OFN21_n156 B1=n1811
+ Y=n1141
XU1578 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1809 B0=FE_OFN88_n60 B1=n1810
+ Y=n1140
XU1579 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1807 B0=FE_OFN10_n64 B1=n1808
+ Y=n1139
XU1580 NAND4X1TR $PINS A=n1142 B=n1141 C=n1140 D=n1139 Y=n2158
XU1581 AOI22X1TR $PINS A0=FE_OFN15_n153 A1=n1853 B0=FE_OFN16_n154 B1=n1854
+ Y=n1146
XU1582 AOI22X1TR $PINS A0=n155 A1=n1852 B0=n156 B1=n1851 Y=n1145
XU1583 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n1849 B0=FE_OFN7_n60 B1=n1850
+ Y=n1144
XU1584 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1847 B0=FE_OFN10_n64 B1=n1848
+ Y=n1143
XU1585 NAND4X1TR $PINS A=n1146 B=n1145 C=n1144 D=n1143 Y=n2160
XU1586 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1893 B0=FE_OFN17_n154 B1=n1894
+ Y=n1157
XU1587 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n1892 B0=FE_OFN21_n156 B1=n1891
+ Y=n1156
XU1588 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1889 B0=FE_OFN88_n60 B1=n1890
+ Y=n1155
XU1589 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1887 B0=FE_OFN10_n64 B1=n1888
+ Y=n1154
XU1590 NAND4X1TR $PINS A=n1157 B=n1156 C=n1155 D=n1154 Y=n2161
XU1591 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1933 B0=FE_OFN17_n154 B1=n1934
+ Y=n1161
XU1592 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n1932 B0=FE_OFN21_n156 B1=n1931
+ Y=n1160
XU1593 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1929 B0=FE_OFN88_n60 B1=n1930
+ Y=n1159
XU1594 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1927 B0=FE_OFN10_n64 B1=n1928
+ Y=n1158
XU1595 NAND4X1TR $PINS A=n1161 B=n1160 C=n1159 D=n1158 Y=n2162
XU1596 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1973 B0=FE_OFN17_n154 B1=n1974
+ Y=n1165
XU1597 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n1972 B0=FE_OFN21_n156 B1=n1971
+ Y=n1164
XU1598 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1969 B0=FE_OFN88_n60 B1=n1970
+ Y=n1163
XU1599 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1967 B0=FE_OFN10_n64 B1=n1968
+ Y=n1162
XU1600 NAND4X1TR $PINS A=n1165 B=n1164 C=n1163 D=n1162 Y=n2163
XU1601 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2013 B0=FE_OFN17_n154 B1=n2014
+ Y=n1169
XU1602 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n2012 B0=FE_OFN21_n156 B1=n2011
+ Y=n1168
XU1603 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n2009 B0=FE_OFN88_n60 B1=n2010
+ Y=n1167
XU1604 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2007 B0=FE_OFN10_n64 B1=n2008
+ Y=n1166
XU1605 NAND4X1TR $PINS A=n1169 B=n1168 C=n1167 D=n1166 Y=n2164
XU1606 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2053 B0=FE_OFN17_n154 B1=n2054
+ Y=n1173
XU1607 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n2052 B0=FE_OFN21_n156 B1=n2051
+ Y=n1172
XU1608 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n2049 B0=FE_OFN88_n60 B1=n2050
+ Y=n1171
XU1609 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2047 B0=FE_OFN10_n64 B1=n2048
+ Y=n1170
XU1610 NAND4X1TR $PINS A=n1173 B=n1172 C=n1171 D=n1170 Y=n2165
XU1611 NOR2BX1TR $PINS AN=n2121 B=n1244 Y=n2159
XU1612 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2093 B0=FE_OFN17_n154 B1=n2094
+ Y=n1177
XU1613 AOI22X1TR $PINS A0=FE_OFN20_n155 A1=n2092 B0=FE_OFN21_n156 B1=n2091
+ Y=n1176
XU1614 AOI22X1TR $PINS A0=FE_OFN78_n157 A1=n2089 B0=FE_OFN8_n60 B1=n2090
+ Y=n1175
XU1615 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2087 B0=FE_OFN10_n64 B1=n2088
+ Y=n1174
XU1616 NAND4X1TR $PINS A=n1177 B=n1176 C=n1175 D=n1174 Y=n2166
XU1617 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1815 B0=n154 B1=n1816 Y=n1181
XU1618 AOI22X1TR $PINS A0=n155 A1=n1787 B0=n156 B1=n1786 Y=n1180
XU1619 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1784 B0=FE_OFN8_n60 B1=n1785
+ Y=n1179
XU1620 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1794 B0=FE_OFN10_n64 B1=n1795
+ Y=n1178
XU1621 NAND4X1TR $PINS A=n1181 B=n1180 C=n1179 D=n1178 Y=n2168
XU1622 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1855 B0=n154 B1=n1856 Y=n1185
XU1623 AOI22X1TR $PINS A0=n155 A1=n1827 B0=n156 B1=n1826 Y=n1184
XU1624 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1824 B0=FE_OFN8_n60 B1=n1825
+ Y=n1183
XU1625 AOI22X1TR $PINS A0=n147 A1=n1834 B0=n64 B1=n1835 Y=n1182
XU1626 NAND4X1TR $PINS A=n1185 B=n1184 C=n1183 D=n1182 Y=n2170
XU1627 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1895 B0=n154 B1=n1896 Y=n1189
XU1628 AOI22X1TR $PINS A0=n155 A1=n1867 B0=n156 B1=n1866 Y=n1188
XU1629 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1864 B0=FE_OFN8_n60 B1=n1865
+ Y=n1187
XU1630 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1874 B0=FE_OFN10_n64 B1=n1875
+ Y=n1186
XU1631 NAND4X1TR $PINS A=n1189 B=n1188 C=n1187 D=n1186 Y=n2171
XU1632 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1935 B0=n154 B1=n1936 Y=n1193
XU1633 AOI22X1TR $PINS A0=n155 A1=n1907 B0=n156 B1=n1906 Y=n1192
XU1634 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1904 B0=FE_OFN8_n60 B1=n1905
+ Y=n1191
XU1635 AOI22X1TR $PINS A0=n147 A1=n1914 B0=n64 B1=n1915 Y=n1190
XU1636 NAND4X1TR $PINS A=n1193 B=n1192 C=n1191 D=n1190 Y=n2172
XU1637 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n1975 B0=n154 B1=n1976 Y=n1198
XU1638 AOI22X1TR $PINS A0=n155 A1=n1947 B0=n156 B1=n1946 Y=n1197
XU1639 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1944 B0=FE_OFN8_n60 B1=n1945
+ Y=n1196
XU1640 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1954 B0=FE_OFN9_n64 B1=n1955
+ Y=n1195
XU1641 NAND4X1TR $PINS A=n1198 B=n1197 C=n1196 D=n1195 Y=n2173
XU1642 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2015 B0=n154 B1=n2016 Y=n1207
XU1643 AOI22X1TR $PINS A0=n155 A1=n1987 B0=n156 B1=n1986 Y=n1206
XU1644 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n1984 B0=FE_OFN8_n60 B1=n1985
+ Y=n1205
XU1645 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n1994 B0=FE_OFN9_n64 B1=n1995
+ Y=n1204
XU1646 NAND4X1TR $PINS A=n1207 B=n1206 C=n1205 D=n1204 Y=n2174
XU1647 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2055 B0=n154 B1=n2056 Y=n1211
XU1648 AOI22X1TR $PINS A0=n155 A1=n2027 B0=n156 B1=n2026 Y=n1210
XU1649 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n2024 B0=FE_OFN8_n60 B1=n2025
+ Y=n1209
XU1650 AOI22X1TR $PINS A0=FE_OFN11_n147 A1=n2034 B0=FE_OFN10_n64 B1=n2035
+ Y=n1208
XU1651 NAND4X1TR $PINS A=n1211 B=n1210 C=n1209 D=n1208 Y=n2175
XU1652 NOR2BX1TR $PINS AN=n2132 B=n1244 Y=n2169
XU1653 AOI22X1TR $PINS A0=FE_OFN14_n153 A1=n2095 B0=n154 B1=n2096 Y=n1215
XU1654 AOI22X1TR $PINS A0=n155 A1=n2067 B0=n156 B1=n2066 Y=n1214
XU1655 AOI22X1TR $PINS A0=FE_OFN25_n157 A1=n2064 B0=FE_OFN8_n60 B1=n2065
+ Y=n1213
XU1656 AOI22X1TR $PINS A0=FE_OFN12_n147 A1=n2074 B0=FE_OFN9_n64 B1=n2075
+ Y=n1212
XU1657 NAND4X1TR $PINS A=n1215 B=n1214 C=n1213 D=n1212 Y=n2176
XU1658 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1792 B0=FE_OFN17_n154 B1=n1793
+ Y=n1219
XU1659 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1791 B0=FE_OFN60_n156 B1=n1790
+ Y=n1218
XU1660 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1788 B0=FE_OFN88_n60 B1=n1789
+ Y=n1217
XU1661 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1797 B0=FE_OFN142_n64 B1=n1796
+ Y=n1216
XU1662 NAND4X1TR $PINS A=n1219 B=n1218 C=n1217 D=n1216 Y=n2178
XU1663 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1832 B0=FE_OFN17_n154 B1=n1833
+ Y=n1223
XU1664 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1831 B0=FE_OFN60_n156 B1=n1830
+ Y=n1222
XU1665 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1828 B0=FE_OFN88_n60 B1=n1829
+ Y=n1221
XU1666 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1837 B0=FE_OFN142_n64 B1=n1836
+ Y=n1220
XU1667 NAND4X1TR $PINS A=n1223 B=n1222 C=n1221 D=n1220 Y=n2180
XU1668 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1872 B0=FE_OFN17_n154 B1=n1873
+ Y=n1227
XU1669 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1871 B0=FE_OFN60_n156 B1=n1870
+ Y=n1226
XU1670 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1868 B0=FE_OFN88_n60 B1=n1869
+ Y=n1225
XU1671 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1877 B0=FE_OFN142_n64 B1=n1876
+ Y=n1224
XU1672 NAND4X1TR $PINS A=n1227 B=n1226 C=n1225 D=n1224 Y=n2181
XU1673 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1912 B0=FE_OFN17_n154 B1=n1913
+ Y=n1231
XU1674 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1911 B0=FE_OFN60_n156 B1=n1910
+ Y=n1230
XU1675 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1908 B0=FE_OFN88_n60 B1=n1909
+ Y=n1229
XU1676 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1917 B0=FE_OFN142_n64 B1=n1916
+ Y=n1228
XU1677 NAND4X1TR $PINS A=n1231 B=n1230 C=n1229 D=n1228 Y=n2182
XU1678 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1952 B0=FE_OFN17_n154 B1=n1953
+ Y=n1235
XU1679 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1951 B0=FE_OFN60_n156 B1=n1950
+ Y=n1234
XU1680 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1948 B0=FE_OFN88_n60 B1=n1949
+ Y=n1233
XU1681 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1957 B0=FE_OFN142_n64 B1=n1956
+ Y=n1232
XU1682 NAND4X1TR $PINS A=n1235 B=n1234 C=n1233 D=n1232 Y=n2183
XU1683 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n1992 B0=FE_OFN17_n154 B1=n1993
+ Y=n1239
XU1684 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n1991 B0=FE_OFN60_n156 B1=n1990
+ Y=n1238
XU1685 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n1988 B0=FE_OFN88_n60 B1=n1989
+ Y=n1237
XU1686 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n1997 B0=FE_OFN142_n64 B1=n1996
+ Y=n1236
XU1687 NAND4X1TR $PINS A=n1239 B=n1238 C=n1237 D=n1236 Y=n2184
XU1688 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n2032 B0=FE_OFN17_n154 B1=n2033
+ Y=n1243
XU1689 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n2031 B0=FE_OFN60_n156 B1=n2030
+ Y=n1242
XU1690 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n2028 B0=FE_OFN88_n60 B1=n2029
+ Y=n1241
XU1691 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n2037 B0=FE_OFN142_n64 B1=n2036
+ Y=n1240
XU1692 NAND4X1TR $PINS A=n1243 B=n1242 C=n1241 D=n1240 Y=n2185
XU1693 NOR2BX1TR $PINS AN=n2133 B=n1244 Y=n2179
XU1694 AOI22X1TR $PINS A0=FE_OFN109_n153 A1=n2072 B0=FE_OFN17_n154 B1=n2073
+ Y=n1256
XU1695 AOI22X1TR $PINS A0=FE_OFN18_n155 A1=n2071 B0=FE_OFN60_n156 B1=n2070
+ Y=n1255
XU1696 AOI22X1TR $PINS A0=FE_OFN79_n157 A1=n2068 B0=FE_OFN88_n60 B1=n2069
+ Y=n1254
XU1697 AOI22X1TR $PINS A0=FE_OFN13_n147 A1=n2077 B0=FE_OFN142_n64 B1=n2076
+ Y=n1253
XU1698 NAND4X1TR $PINS A=n1256 B=n1255 C=n1254 D=n1253 Y=n2186
XU1699 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__2_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<2>
XU1700 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__1_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<1>
XU1701 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__0_ B=FE_OFN4_reset
+ Y=PE_top0_buff_mult_arr0_state_int1<0>
XU1702 NOR2BX1TR $PINS AN=n1752 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<2>
XU1703 NOR2BX1TR $PINS AN=n1753 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<1>
XU1704 NOR2BX1TR $PINS AN=n1754 B=FE_OFN6_reset
+ Y=PE_top0_buff_mult_arr0_state_int2<0>
XU1705 NOR2BX1TR $PINS AN=n1755 B=FE_OFN147_reset Y=PE_top0_ST_MULT<2>
XU1706 NOR2BX1TR $PINS AN=n1756 B=FE_OFN147_reset Y=PE_top0_ST_MULT<1>
XU1707 NOR2BX1TR $PINS AN=n1757 B=FE_OFN147_reset Y=PE_top0_ST_MULT<0>
XU1709 NOR2X1TR $PINS A=FE_OFN28_FE_DBTN3_reset B=n1747 Y=n2187
XU1710 NOR2BX1TR $PINS AN=n1763 B=FE_OFN28_FE_DBTN3_reset Y=n2190
XU1711 NOR2BX1TR $PINS AN=n1762 B=FE_OFN28_FE_DBTN3_reset Y=n2189
XU1712 NOR2BX1TR $PINS AN=n1761 B=FE_DBTN3_reset Y=n2188
Xclk_r_REG181_S1 DFFQX1TR $PINS D=n1375 CK=CTS_6 Q=n1818
XU361 XNOR2X1TR $PINS A=n390 B=n1321 Y=n646
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG77_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n19 CK=CTS_11 Q=n1329
XU442 XNOR2X1TR $PINS A=n698 B=n1325 Y=n230
XU167 INVX4TR $PINS A=n1302 Y=n560
XPE_top0_buff_mult_arr0_mult_x_24_clk_r_REG67_S3 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_24_n31 CK=CTS_11 Q=n1327
XU355 ADDHX1TR $PINS A=n243 B=n242 S=n247 CO=n249
XU941 XNOR2X1TR $PINS A=n1321 B=n698 Y=n406
XPE_top0_buff_mult_arr0_mult_x_27_clk_r_REG114_S2 DFFQX1TR $PINS
+ D=PE_top0_buff_mult_arr0_mult_x_27_n39 CK=CTS_2 Q=n1318
XU604 XOR2X1TR $PINS A=n49 B=n1269 Y=n48
XU674 XOR2X1TR $PINS A=n288 B=n87 Y=n88
XU430 XNOR2X1TR $PINS A=n1321 B=n699 Y=n702
XU858 NOR2BX1TR $PINS AN=n292 B=FE_OFN0_FE_DBTN0_n2107 Y=n293
XU98 OAI21X1TR $PINS A0=n915 A1=n874 B0=FE_OFN30_FE_DBTN3_reset Y=n877
XU322 OAI21X1TR $PINS A0=n879 A1=n913 B0=FE_OFN146_reset Y=n881
XU1196 OAI21X1TR $PINS A0=n934 A1=n907 B0=FE_OFN31_FE_DBTN3_reset Y=n926
XU85 AND2X2TR $PINS A=n250 B=n249 Y=n13
Xclk_r_REG199_S1 DFFQX1TR $PINS D=n1358 CK=CTS_3 Q=n1799
Xclk_r_REG163_S1 DFFQX1TR $PINS D=n1379 CK=CTS_12 Q=n1823
XU536 INVX2TR $PINS A=n911 Y=n966
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG156_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<3> CK=CTS_11 Q=n1264
XPE_top0_buff_mult_arr0_mult_x_33_clk_r_REG158_S1 DFFQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_1__buffer_mult0_mult_A<1> CK=CTS_11 Q=n1266
XPE_top0_buff_mult_arr0_mult_x_30_clk_r_REG148_S1 DFFHQX4TR $PINS
+ D=PE_top0_buff_mult_arr0_genblk1_2__buffer_mult0_mult_A<3> CK=CTS_2 Q=n1282
XU791 NAND2X4TR $PINS A=n207 B=n206 Y=n208
XU788 XNOR2X1TR $PINS A=n1266 B=n504 Y=n209
XU1151 NAND3X1TR $PINS A=pe_in_pk_wrb_addr__2_ B=FE_DBTN2_pe_in_pk_wrb_addr__0
+ C=n891 Y=n915
XU488 XNOR2X1TR $PINS A=n1280 B=n463 Y=n106
XU323 OAI21X2TR $PINS A0=n879 A1=n893 B0=FE_OFN146_reset Y=n895
XU105 OAI21X2TR $PINS A0=n921 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n904
XU104 OAI21X2TR $PINS A0=n910 A1=n900 B0=FE_OFN29_FE_DBTN3_reset Y=n932
XU60 INVX1TR $PINS A=n1291 Y=n86
XU64 CLKINVX2TR $PINS A=n1282 Y=n331
XU76 XNOR2X1TR $PINS A=n1300 B=n167 Y=n135
XU91 INVX2TR $PINS A=n500 Y=n521
XU94 INVX1TR $PINS A=n238 Y=n241
XU121 OR2X1TR $PINS A=n754 B=n753 Y=n749
XU197 OR2X1TR $PINS A=n543 B=n542 Y=n1056
XU198 INVX2TR $PINS A=n806 Y=n821
XU239 INVX2TR $PINS A=n814 Y=n146
XU243 AND2X1TR $PINS A=n1088 B=FE_OFN26_FE_DBTN3_reset Y=PE_top0_OUT_ADD<3>
.ENDS
.GLOBAL VSS
