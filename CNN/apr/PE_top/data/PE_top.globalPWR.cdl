$ Spice netlist generated by v2lvs
$ v2021.3_15.9    Tue Jul 6 13:44:20 PDT 2021
.INCLUDE "/afs/umich.edu/class/eecs627/ibm13/artisan/current/aci/sc-x/lvs_netlist/ibm13.cdl"
.INCLUDE "/afs/umich.edu/class/eecs627/w23/lab_resource/lab3/reset_driver.cdl"
*.BUSDELIMITER <

.SUBCKT buffer_3 reset wrb_data<7> wrb_data<6> wrb_data<5> wrb_data<4>
+ wrb_data<3> wrb_data<2> wrb_data<1> wrb_data<0> wrb_addr<3> wrb_addr<2>
+ wrb_addr<1> wrb_addr<0> wrb rdb_addr<3> rdb_addr<2> rdb_addr<1> rdb_addr<0>
+ data_out<7> data_out<6> data_out<5> data_out<4> data_out<3> data_out<2>
+ data_out<1> data_out<0> FE_OFN7_reset clk_clone2 clk_clone1 clk
XPLACEDFE_OFC121_n60 CLKBUFX2TR $PINS A=FE_OFN33_n60 Y=FE_OFN58_n60
XPLACEDFE_OFC120_n60 BUFX3TR $PINS A=n60 Y=FE_OFN33_n60
XCTS_ccl_a_inv_00012 CLKINVX20TR $PINS A=clk Y=CTS_1
XPLACEDFE_OFC110_pe_in_pk_wrb_addr__1 CLKINVX2TR $PINS A=wrb_addr<1> Y=n24
XPLACEDFE_OFC95_n55 CLKBUFX2TR $PINS A=n55 Y=FE_OFN54_n55
XPLACEDFE_OFC92_n58 CLKBUFX2TR $PINS A=n58 Y=FE_OFN53_n58
XPLACEDFE_OFC90_n31 INVX2TR $PINS A=n31 Y=n44
XPLACEDFE_OFC84_pe_in_pk_wrb_addr__2 CLKINVX2TR $PINS A=wrb_addr<2> Y=n17
XPLACEDFE_OFC79_n16 INVX2TR $PINS A=FE_OFN40_n16 Y=n41
XPLACEDFE_OFC78_n16 CLKBUFX2TR $PINS A=n16 Y=FE_OFN40_n16
XPLACEDFE_OFC74_n1 CLKBUFX2TR $PINS A=FE_OFN25_FE_DBTN7_n1 Y=FE_DBTN7_n1
XPLACEDFE_OFC73_n1 CLKINVX4TR $PINS A=n1 Y=FE_OFN25_FE_DBTN7_n1
XPLACEDFE_OFC72_pe_in_pk_rdb_addr__0 CLKINVX2TR $PINS A=rdb_addr<0> Y=n61
XPLACEDFE_OFC62_reset CLKINVX2TR $PINS A=reset Y=FE_DBTN9_reset
XPLACEDFE_OFC61_reset CLKINVX2TR $PINS A=reset Y=FE_OFN24_FE_DBTN9_reset
XPLACEDFE_OFC49_pe_in_pk_rdb_addr__1 CLKINVX2TR $PINS A=rdb_addr<1> Y=n59
Xclk_r_REG661_S1 DFFQX1TR $PINS D=n178 CK=CTS_1 Q=n284
Xclk_r_REG660_S1 DFFQX1TR $PINS D=n177 CK=clk_clone1 Q=n283
Xclk_r_REG659_S1 DFFQX1TR $PINS D=n176 CK=clk_clone2 Q=n282
Xclk_r_REG658_S1 DFFQX1TR $PINS D=n175 CK=CTS_1 Q=n281
Xclk_r_REG657_S1 DFFQX1TR $PINS D=n174 CK=clk_clone2 Q=n280
Xclk_r_REG656_S1 DFFQX1TR $PINS D=n173 CK=clk_clone2 Q=n279
Xclk_r_REG674_S1 DFFQX1TR $PINS D=n172 CK=CTS_1 Q=n278
Xclk_r_REG673_S1 DFFQX1TR $PINS D=n171 CK=clk_clone2 Q=n277
Xclk_r_REG672_S1 DFFQX1TR $PINS D=n170 CK=CTS_1 Q=n276
Xclk_r_REG702_S1 DFFQX1TR $PINS D=n166 CK=clk_clone1 Q=n272
Xclk_r_REG700_S1 DFFQX1TR $PINS D=n164 CK=CTS_1 Q=n270
Xclk_r_REG699_S1 DFFQX1TR $PINS D=n163 CK=CTS_1 Q=n269
Xclk_r_REG698_S1 DFFQX1TR $PINS D=n162 CK=clk_clone2 Q=n268
Xclk_r_REG697_S1 DFFQX1TR $PINS D=n161 CK=clk_clone2 Q=n267
Xclk_r_REG713_S1 DFFQX1TR $PINS D=n157 CK=clk_clone1 Q=n263
Xclk_r_REG711_S1 DFFQX1TR $PINS D=n155 CK=CTS_1 Q=n261
Xclk_r_REG710_S1 DFFQX1TR $PINS D=n154 CK=CTS_1 Q=n260
Xclk_r_REG709_S1 DFFQX1TR $PINS D=n153 CK=clk_clone2 Q=n259
Xclk_r_REG708_S1 DFFQX1TR $PINS D=n152 CK=clk_clone2 Q=n258
Xclk_r_REG727_S1 DFFQX1TR $PINS D=n151 CK=CTS_1 Q=n257
Xclk_r_REG724_S1 DFFQX1TR $PINS D=n148 CK=clk_clone1 Q=n254
Xclk_r_REG722_S1 DFFQX1TR $PINS D=n146 CK=CTS_1 Q=n252
Xclk_r_REG721_S1 DFFQX1TR $PINS D=n145 CK=CTS_1 Q=n251
Xclk_r_REG720_S1 DFFQX1TR $PINS D=n144 CK=CTS_1 Q=n250
Xclk_r_REG719_S1 DFFQX1TR $PINS D=n143 CK=clk_clone2 Q=n249
Xclk_r_REG738_S1 DFFQX1TR $PINS D=n142 CK=clk_clone1 Q=n248
Xclk_r_REG735_S1 DFFQX1TR $PINS D=n139 CK=clk_clone1 Q=n245
Xclk_r_REG733_S1 DFFQX1TR $PINS D=n137 CK=CTS_1 Q=n243
Xclk_r_REG732_S1 DFFQX1TR $PINS D=n136 CK=CTS_1 Q=n242
Xclk_r_REG731_S1 DFFQX1TR $PINS D=n135 CK=clk_clone2 Q=n241
Xclk_r_REG730_S1 DFFQX1TR $PINS D=n134 CK=clk_clone2 Q=n240
Xclk_r_REG749_S1 DFFQX1TR $PINS D=n133 CK=clk_clone1 Q=n239
Xclk_r_REG747_S1 DFFQX1TR $PINS D=n131 CK=CTS_1 Q=n237
Xclk_r_REG746_S1 DFFQX1TR $PINS D=n130 CK=clk_clone1 Q=n236
Xclk_r_REG745_S1 DFFQX1TR $PINS D=n129 CK=CTS_1 Q=n235
Xclk_r_REG744_S1 DFFQX1TR $PINS D=n128 CK=CTS_1 Q=n234
Xclk_r_REG743_S1 DFFQX1TR $PINS D=n127 CK=CTS_1 Q=n233
Xclk_r_REG742_S1 DFFQX1TR $PINS D=n126 CK=clk_clone2 Q=n232
Xclk_r_REG741_S1 DFFQX1TR $PINS D=n125 CK=clk_clone2 Q=n231
Xclk_r_REG760_S1 DFFQX1TR $PINS D=n124 CK=CTS_1 Q=n230
Xclk_r_REG759_S1 DFFQX1TR $PINS D=n123 CK=clk_clone1 Q=n229
Xclk_r_REG758_S1 DFFQX1TR $PINS D=n122 CK=CTS_1 Q=n228
Xclk_r_REG757_S1 DFFQX1TR $PINS D=n121 CK=clk_clone1 Q=n227
Xclk_r_REG756_S1 DFFQX1TR $PINS D=n120 CK=CTS_1 Q=n226
Xclk_r_REG755_S1 DFFQX1TR $PINS D=n119 CK=CTS_1 Q=n225
Xclk_r_REG754_S1 DFFQX1TR $PINS D=n118 CK=CTS_1 Q=n224
Xclk_r_REG753_S1 DFFQX1TR $PINS D=n117 CK=clk_clone2 Q=n223
Xclk_r_REG752_S1 DFFQX1TR $PINS D=n116 CK=clk_clone2 Q=n222
Xclk_r_REG677_S1 DFFQX1TR $PINS D=n109 CK=CTS_1 Q=n215
Xclk_r_REG688_S1 DFFQX1TR $PINS D=n100 CK=CTS_1 Q=n206
Xclk_r_REG687_S1 DFFQX1TR $PINS D=n99 CK=clk_clone2 Q=n205
Xclk_r_REG686_S1 DFFQX1TR $PINS D=n98 CK=clk_clone2 Q=n204
Xclk_r_REG706_S2 DFFQX1TR $PINS D=n307 CK=CTS_1 Q=n202
Xclk_r_REG707_S2 DFFQX1TR $PINS D=n309 CK=CTS_1 Q=n201
Xclk_r_REG718_S2 DFFQX1TR $PINS D=n305 CK=CTS_1 Q=n199
Xclk_r_REG728_S2 DFFQX1TR $PINS D=n300 CK=CTS_1 Q=n198
Xclk_r_REG729_S2 DFFQX1TR $PINS D=n302 CK=CTS_1 Q=n197
Xclk_r_REG739_S2 DFFQX1TR $PINS D=n297 CK=clk_clone1 Q=n196
Xclk_r_REG740_S2 DFFQX1TR $PINS D=n299 CK=CTS_1 Q=n195
Xclk_r_REG751_S2 DFFQX1TR $PINS D=n296 CK=clk_clone1 Q=n193
Xclk_r_REG761_S2 DFFQX1TR $PINS D=n291 CK=clk_clone1 Q=n192
Xclk_r_REG762_S2 DFFQX1TR $PINS D=n293 CK=CTS_1 Q=n191
Xclk_r_REG685_S2 DFFQX1TR $PINS D=n290 CK=CTS_1 Q=n189
Xclk_r_REG695_S2 DFFQX1TR $PINS D=n285 CK=CTS_1 Q=n188
Xclk_r_REG696_S2 DFFQX1TR $PINS D=n287 CK=CTS_1 Q=n187
Xclk_r_REG671_S2 DFFQX1TR $PINS D=n306 CK=clk_clone1 Q=n203
Xclk_r_REG714_S1 DFFQX1TR $PINS D=n158 CK=CTS_1 Q=n264
Xclk_r_REG750_S2 DFFQX1TR $PINS D=n294 CK=clk_clone1 Q=n194
Xclk_r_REG705_S1 DFFQX1TR $PINS D=n169 CK=CTS_1 Q=n275
Xclk_r_REG716_S1 DFFQX1TR $PINS D=n160 CK=CTS_1 Q=n266
Xclk_r_REG669_S2 DFFQX1TR $PINS D=n304 CK=CTS_1 Q=n181
Xclk_r_REG683_S1 DFFQX1TR $PINS D=n115 CK=CTS_1 Q=n221
Xclk_r_REG680_S1 DFFQX1TR $PINS D=n112 CK=clk_clone1 Q=n218
Xclk_r_REG678_S1 DFFQX1TR $PINS D=n110 CK=CTS_1 Q=n216
Xclk_r_REG694_S1 DFFQX1TR $PINS D=n106 CK=CTS_1 Q=n212
Xclk_r_REG691_S1 DFFQX1TR $PINS D=n103 CK=clk_clone1 Q=n209
Xclk_r_REG689_S1 DFFQX1TR $PINS D=n101 CK=CTS_1 Q=n207
Xclk_r_REG681_S1 DFFQX1TR $PINS D=n113 CK=CTS_1 Q=n219
Xclk_r_REG675_S1 DFFQX1TR $PINS D=n107 CK=clk_clone2 Q=n213
Xclk_r_REG692_S1 DFFQX1TR $PINS D=n104 CK=CTS_1 Q=n210
Xclk_r_REG703_S1 DFFQX1TR $PINS D=n167 CK=CTS_1 Q=n273
Xclk_r_REG725_S1 DFFQX1TR $PINS D=n149 CK=CTS_1 Q=n255
Xclk_r_REG736_S1 DFFQX1TR $PINS D=n140 CK=clk_clone2 Q=n246
Xclk_r_REG665_S2 DFFQX1TR $PINS D=n292 CK=clk_clone1 Q=n186
Xclk_r_REG717_S2 DFFQX1TR $PINS D=n303 CK=CTS_1 Q=n200
Xclk_r_REG670_S2 DFFQX1TR $PINS D=n308 CK=CTS_1 Q=n182
Xclk_r_REG712_S1 DFFQX1TR $PINS D=n156 CK=CTS_1 Q=n262
Xclk_r_REG684_S2 DFFQX1TR $PINS D=n288 CK=CTS_1 Q=n190
Xclk_r_REG748_S1 DFFQX1TR $PINS D=n132 CK=clk_clone1 Q=n238
Xclk_r_REG668_S2 DFFQX1TR $PINS D=n301 CK=CTS_1 Q=n180
Xclk_r_REG667_S2 DFFQX1TR $PINS D=n298 CK=clk_clone1 Q=n179
Xclk_r_REG662_S2 DFFQX1TR $PINS D=n286 CK=CTS_1 Q=n184
Xclk_r_REG666_S2 DFFQX1TR $PINS D=n295 CK=clk_clone1 Q=n183
Xclk_r_REG664_S2 DFFQX1TR $PINS D=n289 CK=CTS_1 Q=n185
Xclk_r_REG676_S1 DFFQX1TR $PINS D=n108 CK=clk_clone2 Q=n214
Xclk_r_REG679_S1 DFFQX1TR $PINS D=n111 CK=CTS_1 Q=n217
Xclk_r_REG690_S1 DFFQX1TR $PINS D=n102 CK=CTS_1 Q=n208
Xclk_r_REG701_S1 DFFQX1TR $PINS D=n165 CK=clk_clone2 Q=n271
Xclk_r_REG723_S1 DFFQX1TR $PINS D=n147 CK=CTS_1 Q=n253
Xclk_r_REG734_S1 DFFQX1TR $PINS D=n138 CK=clk_clone2 Q=n244
Xclk_r_REG682_S1 DFFQX1TR $PINS D=n114 CK=CTS_1 Q=n220
Xclk_r_REG693_S1 DFFQX1TR $PINS D=n105 CK=clk_clone1 Q=n211
Xclk_r_REG704_S1 DFFQX1TR $PINS D=n168 CK=CTS_1 Q=n274
Xclk_r_REG715_S1 DFFQX1TR $PINS D=n159 CK=clk_clone1 Q=n265
Xclk_r_REG726_S1 DFFQX1TR $PINS D=n150 CK=CTS_1 Q=n256
Xclk_r_REG737_S1 DFFQX1TR $PINS D=n141 CK=clk_clone1 Q=n247
XU3 AOI22X1TR $PINS A0=n96 A1=n221 B0=n95 B1=n91 Y=n289
XU4 INVX2TR $PINS A=n12 Y=n46
XU6 OAI31X4TR $PINS A0=wrb_addr<0> A1=n27 A2=n26 B0=FE_OFN24_FE_DBTN9_reset
+ Y=n28
XU11 NOR2X2TR $PINS A=rdb_addr<0> B=rdb_addr<1> Y=n55
XU19 NOR2X1TR $PINS A=n61 B=n59 Y=n60
XU22 NAND4X1TR $PINS A=n55 B=n278 C=rdb_addr<3> D=FE_DBTN9_reset Y=n57
XU23 NAND3X1TR $PINS A=wrb B=wrb_addr<0> C=n30 Y=n15
XU24 NAND2X1TR $PINS A=wrb B=n30 Y=n27
XU27 INVX2TR $PINS A=wrb_addr<3> Y=n30
XU28 OR2X1TR $PINS A=rdb_addr<3> B=reset Y=n68
XU30 NOR2X1TR $PINS A=rdb_addr<2> B=n57 Y=n96
XU31 OR2X2TR $PINS A=rdb_addr<1> B=n61 Y=n1
XU32 NOR2BX2TR $PINS AN=wrb_data<2> B=FE_OFN7_reset Y=n34
XU33 NOR2BX2TR $PINS AN=wrb_data<3> B=reset Y=n35
XU34 NOR2BX2TR $PINS AN=wrb_data<4> B=FE_OFN7_reset Y=n36
XU35 NOR2BX2TR $PINS AN=wrb_data<5> B=reset Y=n37
XU36 NOR2BX2TR $PINS AN=wrb_data<6> B=FE_OFN7_reset Y=n38
XU37 NOR2BX2TR $PINS AN=wrb_data<7> B=FE_OFN7_reset Y=n39
XU38 OAI2BB1X2TR $PINS A0N=n55 A1N=n284 B0=n62 Y=n63
XU39 AOI22X2TR $PINS A0=FE_OFN33_n60 A1=n276 B0=FE_OFN25_FE_DBTN7_n1 B1=n281
+ Y=n62
XU40 OAI2BB1X1TR $PINS A0N=n60 A1N=n280 B0=n64 Y=n65
XU43 AOI211X1TR $PINS A0=n283 A1=n58 B0=n69 C0=n63 Y=n67
XU44 OAI21X1TR $PINS A0=n20 A1=n15 B0=FE_OFN24_FE_DBTN9_reset Y=n16
XU45 AOI32X4TR $PINS A0=n187 A1=n184 A2=n188 B0=n203 B1=n184 Y=data_out<0>
XU46 AOI32X4TR $PINS A0=n201 A1=n182 A2=n202 B0=n203 B1=n182 Y=data_out<7>
XU47 AOI32X4TR $PINS A0=n199 A1=n181 A2=n200 B0=n203 B1=n181 Y=data_out<6>
XU48 AOI32X4TR $PINS A0=n197 A1=n180 A2=n198 B0=n203 B1=n180 Y=data_out<5>
XU49 AOI32X4TR $PINS A0=n189 A1=n185 A2=n190 B0=n203 B1=n185 Y=data_out<1>
XU50 AOI32X4TR $PINS A0=n193 A1=n183 A2=n194 B0=n203 B1=n183 Y=data_out<3>
XU51 AOI32X4TR $PINS A0=n195 A1=n179 A2=n196 B0=n203 B1=n179 Y=data_out<4>
XU52 AOI32X4TR $PINS A0=n191 A1=n186 A2=n192 B0=n203 B1=n186 Y=data_out<2>
XU54 OAI31X4TR $PINS A0=wrb_addr<1> A1=n15 A2=wrb_addr<2>
+ B0=FE_OFN24_FE_DBTN9_reset Y=n12
XU55 NOR2BX2TR $PINS AN=wrb_data<0> B=FE_OFN7_reset Y=n32
XU56 AO22X1TR $PINS A0=n12 A1=n32 B0=n46 B1=n204 Y=n98
XU57 OAI31X4TR $PINS A0=wrb_addr<2> A1=n24 A2=n15 B0=FE_OFN24_FE_DBTN9_reset
+ Y=n13
XU58 INVX2TR $PINS A=n13 Y=n47
XU59 AO22X1TR $PINS A0=n13 A1=n32 B0=n47 B1=n205 Y=n99
XU60 OAI31X4TR $PINS A0=wrb_addr<1> A1=n17 A2=n15 B0=FE_OFN24_FE_DBTN9_reset
+ Y=n14
XU61 INVX2TR $PINS A=n14 Y=n48
XU62 AO22X1TR $PINS A0=n14 A1=n32 B0=n48 B1=n206 Y=n100
XU63 NAND2X1TR $PINS A=wrb_addr<1> B=wrb_addr<2> Y=n20
XU65 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n32 B0=n41 B1=n207 Y=n101
XU66 NAND2BX1TR $PINS AN=wrb_addr<0> B=n17 Y=n22
XU67 OAI31X4TR $PINS A0=n24 A1=n22 A2=n27 B0=FE_OFN24_FE_DBTN9_reset Y=n18
XU68 INVX2TR $PINS A=n18 Y=n49
XU69 AO22X1TR $PINS A0=n18 A1=n32 B0=n49 B1=n208 Y=n102
XU70 NOR3X1TR $PINS A=wrb_addr<1> B=wrb_addr<2> C=wrb_addr<0> Y=n19
XU71 OAI21X1TR $PINS A0=n19 A1=n30 B0=wrb Y=n29
XU72 OAI31X4TR $PINS A0=wrb_addr<0> A1=n29 A2=n20 B0=FE_OFN24_FE_DBTN9_reset
+ Y=n21
XU74 INVX2TR $PINS A=n21 Y=n50
XU75 AO22X1TR $PINS A0=n21 A1=n32 B0=n50 B1=n209 Y=n103
XU76 OAI31X4TR $PINS A0=wrb_addr<1> A1=n27 A2=n22 B0=FE_OFN24_FE_DBTN9_reset
+ Y=n23
XU77 INVX2TR $PINS A=n23 Y=n43
XU78 AO22X1TR $PINS A0=n23 A1=n32 B0=n43 B1=n210 Y=n104
XU79 NAND2X1TR $PINS A=wrb_addr<2> B=n24 Y=n26
XU80 INVX2TR $PINS A=n28 Y=n52
XU81 AO22X1TR $PINS A0=n28 A1=n32 B0=n52 B1=n211 Y=n105
XU82 OAI21X2TR $PINS A0=n30 A1=n29 B0=FE_OFN24_FE_DBTN9_reset Y=n31
XU84 AO22X1TR $PINS A0=n31 A1=n32 B0=n44 B1=n212 Y=n106
XU85 NOR2BX2TR $PINS AN=wrb_data<1> B=FE_OFN7_reset Y=n33
XU86 AO22X1TR $PINS A0=n12 A1=n33 B0=n46 B1=n213 Y=n107
XU87 AO22X1TR $PINS A0=n13 A1=n33 B0=n47 B1=n214 Y=n108
XU88 AO22X1TR $PINS A0=n14 A1=n33 B0=n48 B1=n215 Y=n109
XU89 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n33 B0=n41 B1=n216 Y=n110
XU90 AO22X1TR $PINS A0=n18 A1=n33 B0=n49 B1=n217 Y=n111
XU91 AO22X1TR $PINS A0=n21 A1=n33 B0=n50 B1=n218 Y=n112
XU92 AO22X1TR $PINS A0=n23 A1=n33 B0=n43 B1=n219 Y=n113
XU93 AO22X1TR $PINS A0=n28 A1=n33 B0=n52 B1=n220 Y=n114
XU94 AO22X1TR $PINS A0=n31 A1=n33 B0=n44 B1=n221 Y=n115
XU95 AO22X1TR $PINS A0=n12 A1=n34 B0=n46 B1=n222 Y=n116
XU96 AO22X1TR $PINS A0=n13 A1=n34 B0=n47 B1=n223 Y=n117
XU97 AO22X1TR $PINS A0=n14 A1=n34 B0=n48 B1=n224 Y=n118
XU98 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n34 B0=n41 B1=n225 Y=n119
XU99 AO22X1TR $PINS A0=n18 A1=n34 B0=n49 B1=n226 Y=n120
XU100 AO22X1TR $PINS A0=n21 A1=n34 B0=n50 B1=n227 Y=n121
XU101 AO22X1TR $PINS A0=n23 A1=n34 B0=n43 B1=n228 Y=n122
XU102 AO22X1TR $PINS A0=n28 A1=n34 B0=n52 B1=n229 Y=n123
XU103 AO22X1TR $PINS A0=n31 A1=n34 B0=n44 B1=n230 Y=n124
XU104 AO22X1TR $PINS A0=n12 A1=n35 B0=n46 B1=n231 Y=n125
XU105 AO22X1TR $PINS A0=n13 A1=n35 B0=n47 B1=n232 Y=n126
XU106 AO22X1TR $PINS A0=n14 A1=n35 B0=n48 B1=n233 Y=n127
XU107 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n35 B0=n41 B1=n234 Y=n128
XU108 AO22X1TR $PINS A0=n18 A1=n35 B0=n49 B1=n235 Y=n129
XU109 AO22X1TR $PINS A0=n21 A1=n35 B0=n50 B1=n236 Y=n130
XU110 AO22X1TR $PINS A0=n23 A1=n35 B0=n43 B1=n237 Y=n131
XU111 AO22X1TR $PINS A0=n28 A1=n35 B0=n52 B1=n238 Y=n132
XU112 AO22X1TR $PINS A0=n31 A1=n35 B0=n44 B1=n239 Y=n133
XU113 AO22X1TR $PINS A0=n12 A1=n36 B0=n46 B1=n240 Y=n134
XU114 AO22X1TR $PINS A0=n13 A1=n36 B0=n47 B1=n241 Y=n135
XU115 AO22X1TR $PINS A0=n14 A1=n36 B0=n48 B1=n242 Y=n136
XU116 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n36 B0=n41 B1=n243 Y=n137
XU117 AO22X1TR $PINS A0=n18 A1=n36 B0=n49 B1=n244 Y=n138
XU118 AO22X1TR $PINS A0=n21 A1=n36 B0=n50 B1=n245 Y=n139
XU119 AO22X1TR $PINS A0=n23 A1=n36 B0=n43 B1=n246 Y=n140
XU120 AO22X1TR $PINS A0=n28 A1=n36 B0=n52 B1=n247 Y=n141
XU121 AO22X1TR $PINS A0=n31 A1=n36 B0=n44 B1=n248 Y=n142
XU122 AO22X1TR $PINS A0=n12 A1=n37 B0=n46 B1=n249 Y=n143
XU123 AO22X1TR $PINS A0=n13 A1=n37 B0=n47 B1=n250 Y=n144
XU124 AO22X1TR $PINS A0=n14 A1=n37 B0=n48 B1=n251 Y=n145
XU125 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n37 B0=n41 B1=n252 Y=n146
XU126 AO22X1TR $PINS A0=n18 A1=n37 B0=n49 B1=n253 Y=n147
XU127 AO22X1TR $PINS A0=n21 A1=n37 B0=n50 B1=n254 Y=n148
XU128 AO22X1TR $PINS A0=n23 A1=n37 B0=n43 B1=n255 Y=n149
XU129 AO22X1TR $PINS A0=n28 A1=n37 B0=n52 B1=n256 Y=n150
XU130 AO22X1TR $PINS A0=n31 A1=n37 B0=n44 B1=n257 Y=n151
XU131 AO22X1TR $PINS A0=n12 A1=n38 B0=n46 B1=n258 Y=n152
XU132 AO22X1TR $PINS A0=n13 A1=n38 B0=n47 B1=n259 Y=n153
XU133 AO22X1TR $PINS A0=n14 A1=n38 B0=n48 B1=n260 Y=n154
XU134 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n38 B0=n41 B1=n261 Y=n155
XU135 AO22X1TR $PINS A0=n18 A1=n38 B0=n49 B1=n262 Y=n156
XU136 AO22X1TR $PINS A0=n21 A1=n38 B0=n50 B1=n263 Y=n157
XU137 AO22X1TR $PINS A0=n23 A1=n38 B0=n43 B1=n264 Y=n158
XU138 AO22X1TR $PINS A0=n28 A1=n38 B0=n52 B1=n265 Y=n159
XU139 AO22X1TR $PINS A0=n31 A1=n38 B0=n44 B1=n266 Y=n160
XU140 AO22X1TR $PINS A0=n12 A1=n39 B0=n46 B1=n267 Y=n161
XU141 AO22X1TR $PINS A0=n13 A1=n39 B0=n47 B1=n268 Y=n162
XU142 AO22X1TR $PINS A0=n14 A1=n39 B0=n48 B1=n269 Y=n163
XU143 AO22X1TR $PINS A0=FE_OFN40_n16 A1=n39 B0=n41 B1=n270 Y=n164
XU144 AO22X1TR $PINS A0=n18 A1=n39 B0=n49 B1=n271 Y=n165
XU145 AO22X1TR $PINS A0=n21 A1=n39 B0=n50 B1=n272 Y=n166
XU146 AO22X1TR $PINS A0=n23 A1=n39 B0=n43 B1=n273 Y=n167
XU147 AO22X1TR $PINS A0=n28 A1=n39 B0=n52 B1=n274 Y=n168
XU148 AO22X1TR $PINS A0=n31 A1=n39 B0=n44 B1=n275 Y=n169
XU149 AO22X1TR $PINS A0=FE_OFN40_n16 A1=FE_DBTN9_reset B0=n41 B1=n276 Y=n170
XU150 AO22X1TR $PINS A0=n23 A1=FE_OFN24_FE_DBTN9_reset B0=n43 B1=n277 Y=n171
XU151 AO22X1TR $PINS A0=n31 A1=FE_DBTN9_reset B0=n44 B1=n278 Y=n172
XU152 AO22X1TR $PINS A0=n12 A1=FE_OFN24_FE_DBTN9_reset B0=n46 B1=n279 Y=n173
XU153 AO22X1TR $PINS A0=n13 A1=FE_OFN24_FE_DBTN9_reset B0=n47 B1=n280 Y=n174
XU154 AO22X1TR $PINS A0=n14 A1=FE_DBTN9_reset B0=n48 B1=n281 Y=n175
XU155 AO22X1TR $PINS A0=n18 A1=FE_OFN24_FE_DBTN9_reset B0=n49 B1=n282 Y=n176
XU156 AO22X1TR $PINS A0=n21 A1=FE_DBTN9_reset B0=n50 B1=n283 Y=n177
XU157 AO22X1TR $PINS A0=n28 A1=FE_DBTN9_reset B0=n52 B1=n284 Y=n178
XU160 NOR2X1TR $PINS A=rdb_addr<0> B=n59 Y=n58
XU161 AOI22X1TR $PINS A0=FE_OFN25_FE_DBTN7_n1 A1=n279 B0=n58 B1=n282 Y=n64
XU162 AOI211X1TR $PINS A0=n55 A1=n277 B0=rdb_addr<2> C0=n65 Y=n66
XU163 NOR3X2TR $PINS A=n68 B=n67 C=n66 Y=n82
XU164 AND2X6TR $PINS A=n82 B=n69 Y=n95
XU165 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n241 B0=FE_OFN25_FE_DBTN7_n1 B1=n240
+ Y=n71
XU166 AOI22X1TR $PINS A0=n55 A1=n246 B0=FE_OFN53_n58 B1=n244 Y=n70
XU167 NAND2X1TR $PINS A=n71 B=n70 Y=n72
XU168 AOI22X1TR $PINS A0=n96 A1=n248 B0=n95 B1=n72 Y=n298
XU169 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n250 B0=FE_OFN25_FE_DBTN7_n1 B1=n249
+ Y=n74
XU170 AOI22X1TR $PINS A0=n55 A1=n255 B0=FE_OFN53_n58 B1=n253 Y=n73
XU171 NAND2X1TR $PINS A=n74 B=n73 Y=n75
XU172 AOI22X1TR $PINS A0=n96 A1=n257 B0=n95 B1=n75 Y=n301
XU173 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n259 B0=FE_OFN25_FE_DBTN7_n1 B1=n258
+ Y=n77
XU174 AOI22X1TR $PINS A0=n55 A1=n264 B0=FE_OFN53_n58 B1=n262 Y=n76
XU175 NAND2X1TR $PINS A=n77 B=n76 Y=n78
XU176 AOI22X1TR $PINS A0=n96 A1=n266 B0=n95 B1=n78 Y=n304
XU177 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n268 B0=FE_OFN25_FE_DBTN7_n1 B1=n267
+ Y=n80
XU178 AOI22X1TR $PINS A0=n55 A1=n273 B0=FE_OFN53_n58 B1=n271 Y=n79
XU179 NAND2X1TR $PINS A=n80 B=n79 Y=n81
XU180 AOI22X1TR $PINS A0=n96 A1=n275 B0=n95 B1=n81 Y=n308
XU181 NAND2X1TR $PINS A=rdb_addr<2> B=n82 Y=n306
XU182 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n232 B0=FE_OFN25_FE_DBTN7_n1 B1=n231
+ Y=n84
XU183 AOI22X1TR $PINS A0=n55 A1=n237 B0=FE_OFN53_n58 B1=n235 Y=n83
XU184 NAND2X1TR $PINS A=n84 B=n83 Y=n85
XU185 AOI22X1TR $PINS A0=n96 A1=n239 B0=n95 B1=n85 Y=n295
XU186 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n205 B0=FE_OFN25_FE_DBTN7_n1 B1=n204
+ Y=n87
XU187 AOI22X1TR $PINS A0=n55 A1=n210 B0=FE_OFN53_n58 B1=n208 Y=n86
XU188 NAND2X1TR $PINS A=n87 B=n86 Y=n88
XU189 AOI22X1TR $PINS A0=n96 A1=n212 B0=n95 B1=n88 Y=n286
XU190 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n214 B0=FE_OFN25_FE_DBTN7_n1 B1=n213
+ Y=n90
XU191 AOI22X1TR $PINS A0=n55 A1=n219 B0=FE_OFN53_n58 B1=n217 Y=n89
XU192 NAND2X1TR $PINS A=n90 B=n89 Y=n91
XU193 AOI22X1TR $PINS A0=FE_OFN33_n60 A1=n223 B0=FE_OFN25_FE_DBTN7_n1 B1=n222
+ Y=n93
XU194 AOI22X1TR $PINS A0=n55 A1=n228 B0=FE_OFN53_n58 B1=n226 Y=n92
XU195 NAND2X1TR $PINS A=n93 B=n92 Y=n94
XU196 AOI22X1TR $PINS A0=n96 A1=n230 B0=n95 B1=n94 Y=n292
XU197 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n207 B0=FE_OFN25_FE_DBTN7_n1 B1=n206
+ Y=n287
XU198 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n211 B0=n58 B1=n209 Y=n285
XU199 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n216 B0=FE_DBTN7_n1 B1=n215 Y=n290
XU200 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n220 B0=FE_OFN53_n58 B1=n218 Y=n288
XU201 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n225 B0=FE_DBTN7_n1 B1=n224 Y=n293
XU202 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n229 B0=FE_OFN53_n58 B1=n227 Y=n291
XU203 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n234 B0=FE_DBTN7_n1 B1=n233 Y=n296
XU204 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n238 B0=FE_OFN53_n58 B1=n236 Y=n294
XU205 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n243 B0=FE_DBTN7_n1 B1=n242 Y=n299
XU206 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n247 B0=FE_OFN53_n58 B1=n245 Y=n297
XU207 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n252 B0=FE_DBTN7_n1 B1=n251 Y=n302
XU208 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n256 B0=FE_OFN53_n58 B1=n254 Y=n300
XU209 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n261 B0=FE_DBTN7_n1 B1=n260 Y=n305
XU210 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n265 B0=FE_OFN53_n58 B1=n263 Y=n303
XU211 AOI22X1TR $PINS A0=FE_OFN58_n60 A1=n270 B0=FE_OFN25_FE_DBTN7_n1 B1=n269
+ Y=n309
XU212 AOI22X1TR $PINS A0=FE_OFN54_n55 A1=n274 B0=FE_OFN53_n58 B1=n272 Y=n307
XU16 INVX1TR $PINS A=rdb_addr<2> Y=n69
.ENDS

.SUBCKT MULT_single_3 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> B<7> B<6>
+ B<5> B<4> B<3> B<2> B<1> B<0> data_out<7> data_out<6> data_out<5> data_out<4>
+ data_out<3> data_out<2> data_out<1> data_out<0> clk_clone2 clk_clone1 clk
Xclk_r_REG663_S3 DFFQX1TR $PINS D=B<0> CK=clk_clone2 Q=n254
Xclk_r_REG654_S2 DFFQX1TR $PINS D=n265 CK=clk_clone2 Q=n253
Xclk_r_REG640_S2 DFFQX1TR $PINS D=n155 CK=clk_clone2 Q=n250
Xclk_r_REG625_S2 DFFQX1TR $PINS D=n156 CK=clk Q=n249
Xclk_r_REG645_S3 DFFQX4TR $PINS D=n260 CK=clk_clone2 Q=n246
Xclk_r_REG616_S3 DFFQX4TR $PINS D=n261 CK=clk_clone2 Q=n236
Xclk_r_REG604_S2 DFFQX1TR $PINS D=n181 CK=clk_clone2 Q=n234
Xclk_r_REG608_S2 DFFQX1TR $PINS D=n180 CK=clk_clone1 Q=n233
Xclk_r_REG613_S2 DFFQX1TR $PINS D=n182 CK=clk_clone2 Q=n232
Xclk_r_REG618_S2 DFFQX1TR $PINS D=n179 CK=clk_clone1 Q=n231
Xclk_r_REG621_S2 DFFQX1TR $PINS D=n264 CK=clk_clone2 Q=n229
Xclk_r_REG651_S2 DFFQX1TR $PINS D=n161 CK=clk Q=n228
Xclk_r_REG617_S3 DFFQX1TR $PINS D=n256 CK=clk_clone2 Q=n225
Xclk_r_REG643_S2 DFFQX1TR $PINS D=n176 CK=clk_clone2 Q=n224
Xclk_r_REG623_S2 DFFQX1TR $PINS D=n154 CK=clk_clone2 Q=n222
Xclk_r_REG644_S2 DFFQX1TR $PINS D=n177 CK=clk_clone2 Q=n221
Xclk_r_REG627_S2 DFFQX1TR $PINS D=n168 CK=clk Q=n216
Xclk_r_REG636_S2 DFFQX1TR $PINS D=n145 CK=clk Q=n214
Xclk_r_REG649_S2 DFFQX1TR $PINS D=n171 CK=clk Q=n212
Xclk_r_REG646_S2 DFFQX1TR $PINS D=n174 CK=clk_clone1 Q=n211
Xclk_r_REG647_S2 DFFQX1TR $PINS D=n175 CK=clk_clone2 Q=n210
Xclk_r_REG648_S2 DFFQX1TR $PINS D=n173 CK=clk Q=n209
Xclk_r_REG630_S2 DFFQX1TR $PINS D=n184 CK=clk Q=n207
Xclk_r_REG638_S2 DFFQX1TR $PINS D=n169 CK=clk_clone2 Q=n206
Xclk_r_REG652_S2 DFFQX1TR $PINS D=n170 CK=clk_clone2 Q=n203
Xclk_r_REG763_S1 DFFQX1TR $PINS D=reset CK=clk_clone2 Q=n255
Xclk_r_REG764_S2 DFFQX1TR $PINS D=n255 CK=clk_clone2 Q=n251
Xclk_r_REG610_S3 DFFQX1TR $PINS D=n259 CK=clk_clone1 Q=n240
Xclk_r_REG612_S3 DFFQX1TR $PINS D=n147 CK=clk_clone1 Q=n235
Xclk_r_REG622_S3 DFFQX1TR $PINS D=n202 CK=clk_clone2 Q=n252
Xclk_r_REG615_S3 DFFQX1TR $PINS D=n263 CK=clk_clone2 Q=n247
Xclk_r_REG602_S3 DFFQX1TR $PINS D=n164 CK=clk Q=n244
Xclk_r_REG601_S3 DFFQX1TR $PINS D=n80 CK=clk_clone1 Q=n243
Xclk_r_REG611_S3 DFFQX1TR $PINS D=n148 CK=clk_clone1 Q=n242
Xclk_r_REG606_S3 DFFQX1TR $PINS D=n150 CK=clk_clone1 Q=n239
Xclk_r_REG607_S3 DFFQX1TR $PINS D=n151 CK=clk_clone1 Q=n238
Xclk_r_REG600_S3 DFFQX1TR $PINS D=n165 CK=clk_clone1 Q=n227
Xclk_r_REG620_S3 DFFQX1TR $PINS D=n79 CK=clk_clone1 Q=n226
Xclk_r_REG632_S2 DFFQX1TR $PINS D=n187 CK=clk Q=n220
Xclk_r_REG635_S2 DFFQX1TR $PINS D=n185 CK=clk_clone2 Q=n218
Xclk_r_REG605_S3 DFFQX1TR $PINS D=n257 CK=clk_clone2 Q=n237
Xclk_r_REG633_S2 DFFQX1TR $PINS D=n186 CK=clk Q=n219
Xclk_r_REG628_S2 DFFQX1TR $PINS D=n167 CK=clk Q=n215
Xclk_r_REG614_S3 DFFQX2TR $PINS D=n262 CK=clk_clone2 Q=n248
Xclk_r_REG619_S2 DFFQX1TR $PINS D=n178 CK=clk_clone1 Q=n230
Xclk_r_REG650_S2 DFFQX1TR $PINS D=n172 CK=clk_clone1 Q=n208
Xclk_r_REG609_S3 DFFQX1TR $PINS D=n258 CK=clk_clone1 Q=n241
Xclk_r_REG629_S2 DFFQX1TR $PINS D=n166 CK=clk Q=n204
Xclk_r_REG599_S2 DFFQX1TR $PINS D=n162 CK=clk_clone1 Q=n205
Xclk_r_REG637_S2 DFFQX1TR $PINS D=n188 CK=clk Q=n213
Xclk_r_REG634_S2 DFFQX1TR $PINS D=n146 CK=clk Q=n223
Xclk_r_REG603_S3 DFFQX1TR $PINS D=n158 CK=clk_clone1 Q=n245
XU1 AOI22X1TR $PINS A0=A<5> A1=n152 B0=B<4> B1=n138 Y=n137
XU2 INVX2TR $PINS A=B<0> Y=n193
XU4 INVX2TR $PINS A=B<4> Y=n152
XU5 INVX2TR $PINS A=B<2> Y=n129
XU8 XNOR2X1TR $PINS A=n70 B=n69 Y=n72
XU9 INVX2TR $PINS A=n219 Y=n18
XU10 INVX2TR $PINS A=n111 Y=n71
XU11 AOI21X1TR $PINS A0=n212 A1=n217 B0=n19 Y=n11
XU12 OAI21X1TR $PINS A0=n68 A1=n239 B0=n238 Y=n70
XU13 AND2X4TR $PINS A=n55 B=n54 Y=data_out<1>
XU14 NAND2X1TR $PINS A=n244 B=n227 Y=n107
XU15 XOR2X1TR $PINS A=n85 B=n84 Y=n86
XU16 OR2X2TR $PINS A=n251 B=n255 Y=n111
XU17 CLKINVX2TR $PINS A=n75 Y=data_out<0>
XU18 OA21XLTR $PINS A0=n45 A1=n222 B0=n44 Y=n202
XU19 AO21X1TR $PINS A0=n27 A1=n197 B0=n119 Y=n161
XU20 CLKINVX2TR $PINS A=A<0> Y=n81
XU21 INVX1TR $PINS A=n27 Y=n265
XU22 NAND2X1TR $PINS A=n6 B=n5 Y=n4
XU23 OAI211X1TR $PINS A0=n144 A1=n81 B0=A<1> C0=n193 Y=n154
XU24 INVX1TR $PINS A=n260 Y=n95
XU25 OR2X2TR $PINS A=A<2> B=A<1> Y=n113
XU26 INVX2TR $PINS A=B<1> Y=n144
XU27 INVX1TR $PINS A=A<1> Y=n50
XU29 NAND2X1TR $PINS A=n61 B=n60 Y=n64
XU30 XOR2X1TR $PINS A=n109 B=n66 Y=n67
XU31 NOR3X1TR $PINS A=n247 B=n248 C=n252 Y=n73
XU32 NOR2X1TR $PINS A=n235 B=n58 Y=n24
XU33 XNOR2X1TR $PINS A=n21 B=n20 Y=n158
XU34 XNOR2X1TR $PINS A=n17 B=n16 Y=n21
XU35 NOR3X4TR $PINS A=n248 B=n246 C=n236 Y=n51
XU36 CLKINVX2TR $PINS A=n235 Y=n7
XU37 NOR2BX1TR $PINS AN=n107 B=n108 Y=n66
XU38 XOR2X1TR $PINS A=n231 B=n87 Y=n10
XU39 XOR2X1TR $PINS A=n9 B=n211 Y=n87
XU40 AND2X4TR $PINS A=n23 B=n84 Y=n57
XU41 NOR2X2TR $PINS A=n67 B=n111 Y=data_out<6>
XU42 AOI21X1TR $PINS A0=n242 A1=n235 B0=n56 Y=n65
XU43 NAND2BX1TR $PINS AN=n56 B=n62 Y=n3
XU44 NOR2X1TR $PINS A=n243 B=n226 Y=n56
XU45 AND2X2TR $PINS A=n233 B=n206 Y=n89
XU47 INVX1TR $PINS A=B<7> Y=n49
XU48 CLKINVX2TR $PINS A=n242 Y=n58
XU49 NAND2X1TR $PINS A=n57 B=n7 Y=n6
XU50 XNOR2X1TR $PINS A=n220 B=n15 Y=n16
XU51 AOI22X1TR $PINS A0=A<3> A1=n139 B0=B<6> B1=n143 Y=n120
XU52 XOR2X1TR $PINS A=n38 B=n37 Y=n47
XU53 OAI21X1TR $PINS A0=n210 A1=n218 B0=n38 Y=n8
XU54 XOR2X1TR $PINS A=n106 B=n94 Y=n97
XU55 NOR2X1TR $PINS A=n32 B=n31 Y=n259
XU56 AND2X1TR $PINS A=n232 B=n48 Y=n262
XU57 CLKINVX1TR $PINS A=n114 Y=n30
XU58 INVX1TR $PINS A=n121 Y=n77
XU59 XOR2X1TR $PINS A=n100 B=n99 Y=n102
XU60 AND2X6TR $PINS A=n2 B=n71 Y=data_out<5>
XU61 XNOR2X2TR $PINS A=n4 B=n3 Y=n2
XU62 AOI21X1TR $PINS A0=n59 A1=n7 B0=n58 Y=n5
XU63 INVX1TR $PINS A=B<6> Y=n139
XU64 AO21X1TR $PINS A0=n101 A1=n100 B0=n36 Y=n165
XU65 NAND2X1TR $PINS A=n32 B=n31 Y=n258
XU66 AOI2BB1X1TR $PINS A0N=n233 A1N=n206 B0=n89 Y=n38
XU67 OAI2BB1X1TR $PINS A0N=n218 A1N=n210 B0=n8 Y=n32
XU68 XOR2X1TR $PINS A=n223 B=n249 Y=n9
XU69 XOR2X1TR $PINS A=n89 B=n10 Y=n31
XU70 XOR2X1TR $PINS A=n215 B=n228 Y=n17
XU71 OR2X2TR $PINS A=n213 B=n216 Y=n40
XU72 INVX1TR $PINS A=n40 Y=n35
XU73 NOR2X1TR $PINS A=n217 B=n212 Y=n19
XU74 XOR2X1TR $PINS A=n11 B=n18 Y=n43
XU75 INVX1TR $PINS A=n43 Y=n14
XU76 AND2X2TR $PINS A=n230 B=n204 Y=n91
XU77 OAI21X1TR $PINS A0=n205 A1=n208 B0=n91 Y=n12
XU78 OAI2BB1X1TR $PINS A0N=n208 A1N=n205 B0=n12 Y=n41
XU79 OAI21X1TR $PINS A0=n43 A1=n40 B0=n41 Y=n13
XU80 OAI21X1TR $PINS A0=n35 A1=n14 B0=n13 Y=n15
XU81 AOI32X1TR $PINS A0=n212 A1=n219 A2=n217 B0=n19 B1=n18 Y=n20
XU82 OAI21X1TR $PINS A0=n240 A1=n238 B0=n241 Y=n59
XU83 CLKINVX2TR $PINS A=n225 Y=n22
XU84 OAI21X2TR $PINS A0=n51 A1=n237 B0=n22 Y=n84
XU85 NOR2X1TR $PINS A=n240 B=n239 Y=n23
XU86 NOR2X2TR $PINS A=n59 B=n57 Y=n25
XU87 XOR2X1TR $PINS A=n25 B=n24 Y=n26
XU88 NOR2X2TR $PINS A=n111 B=n26 Y=data_out<4>
XU89 NAND2X1TR $PINS A=A<2> B=A<1> Y=n28
XU90 OAI21X1TR $PINS A0=A<2> A1=A<1> B0=n28 Y=n27
XU92 INVX2TR $PINS A=A<3> Y=n143
XU93 AO22X1TR $PINS A0=A<3> A1=n113 B0=n28 B1=n143 Y=n197
XU94 OAI22X1TR $PINS A0=n143 A1=n49 B0=B<7> B1=A<3> Y=n119
XU95 NAND2X1TR $PINS A=A<5> B=A<6> Y=n29
XU96 OAI21X1TR $PINS A0=A<5> A1=A<6> B0=n29 Y=n134
XU97 INVX2TR $PINS A=A<7> Y=n125
XU98 NOR3X1TR $PINS A=A<5> B=A<6> C=n125 Y=n114
XU99 OAI31X1TR $PINS A0=n134 A1=n125 A2=B<0> B0=n30 Y=n166
XU100 XOR2X1TR $PINS A=n208 B=n91 Y=n33
XU101 XOR2X1TR $PINS A=n33 B=n205 Y=n101
XU102 OAI21X1TR $PINS A0=n209 A1=n214 B0=n207 Y=n34
XU103 OAI2BB1X1TR $PINS A0N=n214 A1N=n209 B0=n34 Y=n100
XU105 AOI2BB1X1TR $PINS A0N=n101 A1N=n100 B0=n99 Y=n36
XU106 XOR2X1TR $PINS A=n210 B=n218 Y=n37
XU107 OAI21X1TR $PINS A0=n234 A1=n250 B0=n224 Y=n39
XU108 OAI2BB1X1TR $PINS A0N=n250 A1N=n234 B0=n39 Y=n46
XU109 NOR2X1TR $PINS A=n47 B=n46 Y=n150
XU110 AOI2BB1X1TR $PINS A0N=n203 A1N=n221 B0=n260 Y=n48
XU111 NOR2X1TR $PINS A=n232 B=n48 Y=n263
XU112 XOR2X1TR $PINS A=n41 B=n40 Y=n42
XU113 XOR2X1TR $PINS A=n43 B=n42 Y=n164
XU114 AOI21X1TR $PINS A0=n253 A1=n254 B0=n229 Y=n45
XU115 NAND3X1TR $PINS A=n254 B=n253 C=n229 Y=n44
XU116 NOR2X1TR $PINS A=n263 B=n202 Y=n261
XU117 NAND2X1TR $PINS A=n47 B=n46 Y=n151
XU118 AOI32X1TR $PINS A0=B<7> A1=n50 A2=A<0> B0=n49 B1=A<1> Y=n162
XU119 INVX1TR $PINS A=n255 Y=n55
XU120 NOR2X1TR $PINS A=n225 B=n51 Y=n52
XU121 XOR2X1TR $PINS A=n52 B=n237 Y=n53
XU122 NOR2X2TR $PINS A=n53 B=n251 Y=n54
XU123 NAND2X1TR $PINS A=n243 B=n226 Y=n62
XU124 INVX2TR $PINS A=n57 Y=n61
XU125 NOR2X1TR $PINS A=n59 B=n58 Y=n60
XU126 CLKINVX2TR $PINS A=n62 Y=n63
XU127 AOI21X2TR $PINS A0=n65 A1=n64 B0=n63 Y=n109
XU128 NOR2X1TR $PINS A=n244 B=n227 Y=n108
XU129 CLKINVX2TR $PINS A=n84 Y=n68
XU130 NAND2BX1TR $PINS AN=n240 B=n241 Y=n69
XU131 AND2X2TR $PINS A=n72 B=n71 Y=data_out<3>
XU132 OA21X2TR $PINS A0=n247 A1=n248 B0=n252 Y=n74
XU133 OR4X2TR $PINS A=n74 B=n73 C=n251 D=n255 Y=n75
XU134 NAND2X1TR $PINS A=A<3> B=A<4> Y=n76
XU135 OAI21X1TR $PINS A0=A<3> A1=A<4> B0=n76 Y=n191
XU136 NOR3X1TR $PINS A=A<3> B=A<4> C=n138 Y=n121
XU137 OAI31X1TR $PINS A0=n191 A1=n138 A2=B<0> B0=n77 Y=n169
XU138 NAND2X1TR $PINS A=A<1> B=A<0> Y=n160
XU139 NOR2X1TR $PINS A=A<1> B=n81 Y=n157
XU140 AND2X2TR $PINS A=n81 B=A<1> Y=n153
XU141 CLKINVX2TR $PINS A=B<3> Y=n123
XU142 AOI22X1TR $PINS A0=B<4> A1=n157 B0=n153 B1=n123 Y=n82
XU143 OAI21X1TR $PINS A0=B<4> A1=n160 B0=n82 Y=n181
XU144 AOI22X1TR $PINS A0=n157 A1=B<2> B0=n153 B1=n144 Y=n83
XU145 OAI21X1TR $PINS A0=B<2> A1=n160 B0=n83 Y=n264
XU146 NAND2BX1TR $PINS AN=n239 B=n238 Y=n85
XU147 NOR2X1TR $PINS A=n111 B=n86 Y=data_out<2>
XU148 OAI21X1TR $PINS A0=n89 A1=n231 B0=n87 Y=n88
XU149 OAI2BB1X1TR $PINS A0N=n231 A1N=n89 B0=n88 Y=n98
XU150 XOR2X1TR $PINS A=n214 B=n207 Y=n90
XU151 XOR2X1TR $PINS A=n209 B=n90 Y=n106
XU152 AOI2BB1X1TR $PINS A0N=n204 A1N=n230 B0=n91 Y=n103
XU153 OAI21X1TR $PINS A0=n223 A1=n249 B0=n211 Y=n93
XU154 NAND2X1TR $PINS A=n223 B=n249 Y=n92
XU155 NAND2X1TR $PINS A=n93 B=n92 Y=n105
XU156 XOR2X1TR $PINS A=n103 B=n105 Y=n94
XU157 NOR2X1TR $PINS A=n98 B=n97 Y=n147
XU158 NOR3BX1TR $PINS AN=n232 B=n202 C=n95 Y=n256
XU159 XOR2X1TR $PINS A=n250 B=n224 Y=n96
XU160 XNOR2X1TR $PINS A=n96 B=n234 Y=n257
XU161 NAND2X1TR $PINS A=n98 B=n97 Y=n148
XU162 XNOR2X1TR $PINS A=n102 B=n101 Y=n80
XU163 OAI21X1TR $PINS A0=n106 A1=n105 B0=n103 Y=n104
XU164 OAI2BB1X1TR $PINS A0N=n106 A1N=n105 B0=n104 Y=n79
XU165 OAI21X1TR $PINS A0=n109 A1=n108 B0=n107 Y=n110
XU166 XOR2X1TR $PINS A=n110 B=n245 Y=n112
XU167 NOR2X2TR $PINS A=n112 B=n111 Y=data_out<7>
XU168 OAI32X1TR $PINS A0=n143 A1=B<0> A2=n27 B0=n113 B1=n143 Y=n170
XU169 AOI31X1TR $PINS A0=A<6> A1=A<5> A2=n125 B0=n114 Y=n133
XU170 AOI22X1TR $PINS A0=B<0> A1=n125 B0=A<7> B1=n193 Y=n115
XU171 AOI22X1TR $PINS A0=A<7> A1=n144 B0=B<1> B1=n125 Y=n126
XU172 OAI22X1TR $PINS A0=n133 A1=n115 B0=n126 B1=n134 Y=n184
XU173 CLKINVX2TR $PINS A=B<5> Y=n136
XU174 AOI22X1TR $PINS A0=A<3> A1=n136 B0=B<5> B1=n143 Y=n116
XU175 OAI22X1TR $PINS A0=n197 A1=n116 B0=n27 B1=n120 Y=n172
XU176 AOI22X1TR $PINS A0=A<3> A1=n152 B0=B<4> B1=n143 Y=n117
XU177 OAI22X1TR $PINS A0=n197 A1=n117 B0=n27 B1=n116 Y=n173
XU178 AOI22X1TR $PINS A0=A<3> A1=n129 B0=B<2> B1=n143 Y=n194
XU179 AOI22X1TR $PINS A0=A<3> A1=n123 B0=B<3> B1=n143 Y=n118
XU180 OAI22X1TR $PINS A0=n197 A1=n194 B0=n27 B1=n118 Y=n175
XU181 OAI22X1TR $PINS A0=n197 A1=n118 B0=n27 B1=n117 Y=n174
XU182 OAI22X1TR $PINS A0=n197 A1=n120 B0=n27 B1=n119 Y=n171
XU183 AOI31X1TR $PINS A0=A<3> A1=A<4> A2=n138 B0=n121 Y=n190
XU184 AOI22X1TR $PINS A0=A<5> A1=n123 B0=B<3> B1=n138 Y=n122
XU185 OAI22X1TR $PINS A0=n190 A1=n122 B0=n137 B1=n191 Y=n188
XU186 AOI22X1TR $PINS A0=A<5> A1=n129 B0=B<2> B1=n138 Y=n163
XU187 OAI22X1TR $PINS A0=n190 A1=n163 B0=n191 B1=n122 Y=n145
XU188 AOI22X1TR $PINS A0=A<7> A1=n123 B0=B<3> B1=n125 Y=n131
XU189 AOI22X1TR $PINS A0=A<7> A1=n152 B0=B<4> B1=n125 Y=n124
XU190 OAI22X1TR $PINS A0=n133 A1=n131 B0=n124 B1=n134 Y=n167
XU191 AOI22X1TR $PINS A0=A<7> A1=n129 B0=B<2> B1=n125 Y=n132
XU192 OAI22X1TR $PINS A0=n133 A1=n126 B0=n132 B1=n134 Y=n168
XU193 AOI22X1TR $PINS A0=B<7> A1=n157 B0=n153 B1=n139 Y=n127
XU194 OAI21X1TR $PINS A0=B<7> A1=n160 B0=n127 Y=n178
XU195 AOI22X1TR $PINS A0=n157 A1=B<6> B0=n153 B1=n136 Y=n128
XU196 OAI21X1TR $PINS A0=B<6> A1=n160 B0=n128 Y=n179
XU197 AOI22X1TR $PINS A0=B<3> A1=n157 B0=n153 B1=n129 Y=n130
XU198 OAI21X1TR $PINS A0=B<3> A1=n160 B0=n130 Y=n182
XU199 OAI22X1TR $PINS A0=n133 A1=n132 B0=n131 B1=n134 Y=n183
XU200 NOR2X1TR $PINS A=n193 B=n134 Y=n156
XU201 AOI22X1TR $PINS A0=B<0> A1=n138 B0=A<5> B1=n193 Y=n135
XU202 AOI22X1TR $PINS A0=A<5> A1=n144 B0=B<1> B1=n138 Y=n189
XU203 OAI22X1TR $PINS A0=n190 A1=n135 B0=n189 B1=n191 Y=n185
XU204 AOI22X1TR $PINS A0=A<5> A1=n136 B0=B<5> B1=n138 Y=n142
XU205 OAI22X1TR $PINS A0=n190 A1=n137 B0=n142 B1=n191 Y=n186
XU206 AOI22X1TR $PINS A0=A<5> A1=n139 B0=B<6> B1=n138 Y=n141
XU207 OAI22X1TR $PINS A0=n190 A1=n142 B0=n141 B1=n191 Y=n187
XU208 AOI22X1TR $PINS A0=A<3> A1=n193 B0=B<0> B1=n143 Y=n149
XU209 AOI22X1TR $PINS A0=A<3> A1=n144 B0=B<1> B1=n143 Y=n196
XU210 OAI22X1TR $PINS A0=n197 A1=n149 B0=n27 B1=n196 Y=n177
XU211 AOI22X1TR $PINS A0=B<5> A1=n157 B0=n153 B1=n152 Y=n159
XU212 OAI21X1TR $PINS A0=B<5> A1=n160 B0=n159 Y=n180
XU213 OAI22X1TR $PINS A0=n190 A1=n189 B0=n163 B1=n191 Y=n146
XU214 NOR2X1TR $PINS A=n193 B=n191 Y=n155
XU215 OAI22X1TR $PINS A0=n197 A1=n196 B0=n27 B1=n194 Y=n176
Xclk_r_REG626_S2 DFFQX1TR $PINS D=n183 CK=clk Q=n217
XU6 INVX2TR $PINS A=A<5> Y=n138
XU104 AOI21X1TR $PINS A0=n216 A1=n213 B0=n35 Y=n99
XU3 AND2X1TR $PINS A=n203 B=n221 Y=n260
.ENDS

.SUBCKT buffer_mult_3 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> wrb_data<7>
+ wrb_data<6> wrb_data<5> wrb_data<4> wrb_data<3> wrb_data<2> wrb_data<1>
+ wrb_data<0> wrb_addr<3> wrb_addr<2> wrb_addr<1> wrb_addr<0> wrb rdb_addr<3>
+ rdb_addr<2> rdb_addr<1> rdb_addr<0> data_out<7> data_out<6> data_out<5>
+ data_out<4> data_out<3> data_out<2> data_out<1> data_out<0> FE_OFN6_reset
+ FE_OFN3_reset FE_OFN1_reset FE_OFN28_reset FE_OFN27_reset clk_clone5
+ clk_clone4 clk_clone3 clk_clone2 clk_clone1 clk
Xclk_r_REG641_S1 DFFQX1TR $PINS D=mult_A<7> CK=clk_clone3 Q=n8
Xclk_r_REG639_S1 DFFQX1TR $PINS D=mult_A<4> CK=clk_clone3 Q=n5
Xclk_r_REG653_S1 DFFQX1TR $PINS D=mult_A<2> CK=clk_clone3 Q=n3
Xclk_r_REG655_S1 DFFQX1TR $PINS D=mult_A<1> CK=clk_clone3 Q=n2
Xclk_r_REG624_S1 DFFQX1TR $PINS D=mult_A<6> CK=clk_clone3 Q=n7
Xclk_r_REG642_S1 DFFQX1TR $PINS D=mult_A<3> CK=clk_clone3 Q=n4
Xclk_r_REG631_S1 DFFQX1TR $PINS D=mult_A<5> CK=clk_clone3 Q=n6
Xclk_r_REG598_S1 DFFQX1TR $PINS D=mult_A<0> CK=clk_clone3 Q=n1
XU4 NOR2BX1TR $PINS AN=A<0> B=FE_OFN1_reset Y=mult_A<0>
XU5 NOR2BX1TR $PINS AN=A<1> B=FE_OFN1_reset Y=mult_A<1>
XU6 NOR2BX1TR $PINS AN=A<2> B=reset Y=mult_A<2>
XU7 NOR2BX1TR $PINS AN=A<3> B=FE_OFN1_reset Y=mult_A<3>
XU8 NOR2BX1TR $PINS AN=A<4> B=FE_OFN3_reset Y=mult_A<4>
XU9 NOR2BX1TR $PINS AN=A<5> B=FE_OFN3_reset Y=mult_A<5>
XU10 NOR2BX1TR $PINS AN=A<6> B=FE_OFN3_reset Y=mult_A<6>
XU11 NOR2BX1TR $PINS AN=A<7> B=FE_OFN3_reset Y=mult_A<7>
Xbuffer0 buffer_3 $PINS reset=FE_OFN28_reset wrb_data<7>=wrb_data<7>
+ wrb_data<6>=wrb_data<6> wrb_data<5>=wrb_data<5> wrb_data<4>=wrb_data<4>
+ wrb_data<3>=wrb_data<3> wrb_data<2>=wrb_data<2> wrb_data<1>=wrb_data<1>
+ wrb_data<0>=wrb_data<0> wrb_addr<3>=wrb_addr<3> wrb_addr<2>=wrb_addr<2>
+ wrb_addr<1>=wrb_addr<1> wrb_addr<0>=wrb_addr<0> wrb=wrb rdb_addr<3>=rdb_addr<3>
+ rdb_addr<2>=rdb_addr<2> rdb_addr<1>=rdb_addr<1> rdb_addr<0>=rdb_addr<0>
+ data_out<7>=buf_data<7> data_out<6>=buf_data<6> data_out<5>=buf_data<5>
+ data_out<4>=buf_data<4> data_out<3>=buf_data<3> data_out<2>=buf_data<2>
+ data_out<1>=buf_data<1> data_out<0>=buf_data<0> FE_OFN7_reset=FE_OFN27_reset
+ clk_clone2=clk_clone2 clk_clone1=clk_clone1 clk=clk
XMULT_single0 MULT_single_3 $PINS reset=FE_OFN6_reset A<7>=n8 A<6>=n7 A<5>=n6
+ A<4>=n5 A<3>=n4 A<2>=n3 A<1>=n2 A<0>=n1 B<7>=buf_data<7> B<6>=buf_data<6>
+ B<5>=buf_data<5> B<4>=buf_data<4> B<3>=buf_data<3> B<2>=buf_data<2>
+ B<1>=buf_data<1> B<0>=buf_data<0> data_out<7>=data_out<7>
+ data_out<6>=data_out<6> data_out<5>=data_out<5> data_out<4>=data_out<4>
+ data_out<3>=data_out<3> data_out<2>=data_out<2> data_out<1>=data_out<1>
+ data_out<0>=data_out<0> clk_clone2=clk_clone5 clk_clone1=clk_clone4
+ clk=clk_clone3
.ENDS

.SUBCKT buffer_2 reset wrb_data<7> wrb_data<6> wrb_data<5> wrb_data<4>
+ wrb_data<3> wrb_data<2> wrb_data<1> wrb_data<0> wrb_addr<3> wrb_addr<2>
+ wrb_addr<1> wrb_addr<0> wrb rdb_addr<3> rdb_addr<2> rdb_addr<1> rdb_addr<0>
+ data_out<7> data_out<6> data_out<5> data_out<4> data_out<3> data_out<2>
+ data_out<1> data_out<0> FE_OFN9_reset FE_OFN29_reset
+ FE_OFN33_pe_in_pk_wrb_addr__2 FE_OFN39_pe_in_pk_wrb_addr__1 clk_clone3
+ clk_clone2 clk_clone1 clk
XPLACEDFE_OFC118_n3 CLKBUFX2TR $PINS A=FE_OFN26_FE_DBTN5_n3 Y=FE_DBTN5_n3
XPLACEDFE_OFC117_n3 INVX2TR $PINS A=n3 Y=FE_OFN26_FE_DBTN5_n3
XPLACEDFE_OFC107_n25 INVX2TR $PINS A=FE_OFN34_n25 Y=n13
XPLACEDFE_OFC106_n25 CLKINVX2TR $PINS A=n25 Y=FE_OFN34_n25
XPLACEDFE_OFC105_pe_in_pk_rdb_addr__2 INVX2TR $PINS A=rdb_addr<2>
+ Y=FE_DBTN8_pe_in_pk_rdb_addr__2
XPLACEDFE_OFC100_n47 CLKINVX1TR $PINS A=n47 Y=FE_OFN56_n47
XPLACEDFE_OFC98_n47 INVX2TR $PINS A=n47 Y=n66
XPLACEDFE_OFC88_n2 CLKINVX2TR $PINS A=n2 Y=FE_DBTN6_n2
XPLACEDFE_OFC87_n2 INVX2TR $PINS A=n2 Y=FE_OFN0_FE_DBTN6_n2
XPLACEDFE_OFC83_pe_in_pk_wrb_addr__2 CLKINVX2TR $PINS A=wrb_addr<2>
+ Y=FE_OFN52_pe_in_pk_wrb_addr__2
XPLACEDFE_OFC80_n36 INVX2TR $PINS A=n36 Y=n64
XPLACEDFE_OFC75_n29 CLKBUFX2TR $PINS A=n29 Y=FE_OFN35_n29
XPLACEDFE_OFC70_pe_in_pk_rdb_addr__0 CLKINVX2TR $PINS A=rdb_addr<0> Y=n27
XPLACEDFE_OFC56_reset CLKBUFX2TR $PINS A=FE_DBTN10_reset
+ Y=FE_OFN23_FE_DBTN10_reset
XPLACEDFE_OFC53_reset CLKINVX2TR $PINS A=reset Y=FE_DBTN10_reset
XPLACEDFE_OFC47_pe_in_pk_rdb_addr__1 CLKINVX2TR $PINS A=rdb_addr<1> Y=n26
Xclk_r_REG493_S1 DFFQX1TR $PINS D=n188 CK=clk_clone1 Q=n294
Xclk_r_REG492_S1 DFFQX1TR $PINS D=n187 CK=clk_clone1 Q=n293
Xclk_r_REG491_S1 DFFQX1TR $PINS D=n186 CK=clk_clone1 Q=n292
Xclk_r_REG506_S1 DFFQX1TR $PINS D=n182 CK=clk_clone1 Q=n288
Xclk_r_REG505_S1 DFFQX1TR $PINS D=n181 CK=clk_clone1 Q=n287
Xclk_r_REG504_S1 DFFQX1TR $PINS D=n180 CK=clk_clone1 Q=n286
Xclk_r_REG537_S1 DFFQX1TR $PINS D=n179 CK=clk Q=n285
Xclk_r_REG536_S1 DFFQX1TR $PINS D=n178 CK=clk Q=n284
Xclk_r_REG535_S1 DFFQX1TR $PINS D=n177 CK=clk Q=n283
Xclk_r_REG534_S1 DFFQX1TR $PINS D=n176 CK=clk Q=n282
Xclk_r_REG533_S1 DFFQX1TR $PINS D=n175 CK=clk Q=n281
Xclk_r_REG548_S1 DFFQX1TR $PINS D=n170 CK=clk Q=n276
Xclk_r_REG547_S1 DFFQX1TR $PINS D=n169 CK=clk_clone1 Q=n275
Xclk_r_REG546_S1 DFFQX1TR $PINS D=n168 CK=clk_clone1 Q=n274
Xclk_r_REG545_S1 DFFQX1TR $PINS D=n167 CK=clk_clone2 Q=n273
Xclk_r_REG544_S1 DFFQX1TR $PINS D=n166 CK=clk_clone1 Q=n272
Xclk_r_REG559_S1 DFFQX1TR $PINS D=n161 CK=clk Q=n267
Xclk_r_REG558_S1 DFFQX1TR $PINS D=n160 CK=clk Q=n266
Xclk_r_REG557_S1 DFFQX1TR $PINS D=n159 CK=clk_clone1 Q=n265
Xclk_r_REG556_S1 DFFQX1TR $PINS D=n158 CK=clk_clone2 Q=n264
Xclk_r_REG555_S1 DFFQX1TR $PINS D=n157 CK=clk_clone1 Q=n263
Xclk_r_REG570_S1 DFFQX1TR $PINS D=n152 CK=clk Q=n258
Xclk_r_REG569_S1 DFFQX1TR $PINS D=n151 CK=clk Q=n257
Xclk_r_REG568_S1 DFFQX1TR $PINS D=n150 CK=clk_clone1 Q=n256
Xclk_r_REG567_S1 DFFQX1TR $PINS D=n149 CK=clk_clone2 Q=n255
Xclk_r_REG566_S1 DFFQX1TR $PINS D=n148 CK=clk Q=n254
Xclk_r_REG581_S1 DFFQX1TR $PINS D=n143 CK=clk Q=n249
Xclk_r_REG580_S1 DFFQX1TR $PINS D=n142 CK=clk Q=n248
Xclk_r_REG579_S1 DFFQX1TR $PINS D=n141 CK=clk Q=n247
Xclk_r_REG578_S1 DFFQX1TR $PINS D=n140 CK=clk Q=n246
Xclk_r_REG577_S1 DFFQX1TR $PINS D=n139 CK=clk Q=n245
Xclk_r_REG592_S1 DFFQX1TR $PINS D=n134 CK=clk Q=n240
Xclk_r_REG591_S1 DFFQX1TR $PINS D=n133 CK=clk_clone1 Q=n239
Xclk_r_REG590_S1 DFFQX1TR $PINS D=n132 CK=clk Q=n238
Xclk_r_REG589_S1 DFFQX1TR $PINS D=n131 CK=clk_clone1 Q=n237
Xclk_r_REG588_S1 DFFQX1TR $PINS D=n130 CK=clk Q=n236
Xclk_r_REG515_S1 DFFQX1TR $PINS D=n125 CK=clk Q=n231
Xclk_r_REG514_S1 DFFQX1TR $PINS D=n124 CK=clk Q=n230
Xclk_r_REG513_S1 DFFQX1TR $PINS D=n123 CK=clk Q=n229
Xclk_r_REG512_S1 DFFQX1TR $PINS D=n122 CK=clk Q=n228
Xclk_r_REG511_S1 DFFQX1TR $PINS D=n121 CK=clk Q=n227
Xclk_r_REG526_S1 DFFQX1TR $PINS D=n116 CK=clk Q=n222
Xclk_r_REG525_S1 DFFQX1TR $PINS D=n115 CK=clk Q=n221
Xclk_r_REG524_S1 DFFQX1TR $PINS D=n114 CK=clk Q=n220
Xclk_r_REG523_S1 DFFQX1TR $PINS D=n113 CK=clk Q=n219
Xclk_r_REG522_S1 DFFQX1TR $PINS D=n112 CK=clk Q=n218
Xclk_r_REG538_S2 DFFQX1TR $PINS D=n317 CK=clk_clone2 Q=n212
Xclk_r_REG539_S2 DFFQX1TR $PINS D=n319 CK=clk_clone2 Q=n211
Xclk_r_REG549_S2 DFFQX1TR $PINS D=n313 CK=clk_clone2 Q=n210
Xclk_r_REG550_S2 DFFQX1TR $PINS D=n315 CK=clk_clone3 Q=n209
Xclk_r_REG560_S2 DFFQX1TR $PINS D=n310 CK=clk_clone2 Q=n208
Xclk_r_REG561_S2 DFFQX1TR $PINS D=n312 CK=clk_clone1 Q=n207
Xclk_r_REG572_S2 DFFQX1TR $PINS D=n309 CK=clk_clone2 Q=n205
Xclk_r_REG582_S2 DFFQX1TR $PINS D=n304 CK=clk Q=n204
Xclk_r_REG583_S2 DFFQX1TR $PINS D=n306 CK=clk Q=n203
Xclk_r_REG593_S2 DFFQX1TR $PINS D=n301 CK=clk_clone2 Q=n202
Xclk_r_REG594_S2 DFFQX1TR $PINS D=n303 CK=clk_clone3 Q=n201
Xclk_r_REG517_S2 DFFQX1TR $PINS D=n300 CK=clk_clone2 Q=n199
Xclk_r_REG527_S2 DFFQX1TR $PINS D=n295 CK=clk Q=n198
Xclk_r_REG528_S2 DFFQX1TR $PINS D=n297 CK=clk_clone2 Q=n197
Xclk_r_REG500_S1 DFFQX1TR $PINS D=n314 CK=clk_clone2 Q=n191
Xclk_r_REG499_S1 DFFQX1TR $PINS D=n311 CK=clk_clone2 Q=n190
Xclk_r_REG494_S1 DFFQX1TR $PINS D=n316 CK=clk_clone1 Q=n213
Xclk_r_REG519_S1 DFFQX1TR $PINS D=n109 CK=clk_clone1 Q=n215
Xclk_r_REG565_S1 DFFQX1TR $PINS D=n147 CK=clk_clone1 Q=n253
Xclk_r_REG501_S1 DFFQX1TR $PINS D=n318 CK=clk_clone2 Q=n192
Xclk_r_REG503_S1 DFFQX1TR $PINS D=n296 CK=clk_clone2 Q=n189
Xclk_r_REG497_S1 DFFQX1TR $PINS D=n302 CK=clk_clone2 Q=n196
Xclk_r_REG574_S1 DFFQX1TR $PINS D=n136 CK=clk_clone1 Q=n242
Xclk_r_REG585_S1 DFFQX1TR $PINS D=n127 CK=clk_clone1 Q=n233
Xclk_r_REG508_S1 DFFQX1TR $PINS D=n118 CK=clk_clone1 Q=n224
Xclk_r_REG502_S1 DFFQX1TR $PINS D=n305 CK=clk Q=n193
Xclk_r_REG490_S1 DFFQX1TR $PINS D=n185 CK=clk_clone1 Q=n291
Xclk_r_REG489_S1 DFFQX1TR $PINS D=n184 CK=clk_clone1 Q=n290
Xclk_r_REG488_S1 DFFQX1TR $PINS D=n183 CK=clk_clone1 Q=n289
Xclk_r_REG576_S1 DFFQX1TR $PINS D=n138 CK=clk_clone1 Q=n244
Xclk_r_REG575_S1 DFFQX1TR $PINS D=n137 CK=clk_clone1 Q=n243
Xclk_r_REG573_S1 DFFQX1TR $PINS D=n135 CK=clk_clone1 Q=n241
Xclk_r_REG587_S1 DFFQX1TR $PINS D=n129 CK=clk_clone1 Q=n235
Xclk_r_REG586_S1 DFFQX1TR $PINS D=n128 CK=clk_clone1 Q=n234
Xclk_r_REG584_S1 DFFQX1TR $PINS D=n126 CK=clk_clone1 Q=n232
Xclk_r_REG510_S1 DFFQX1TR $PINS D=n120 CK=clk_clone1 Q=n226
Xclk_r_REG509_S1 DFFQX1TR $PINS D=n119 CK=clk_clone1 Q=n225
Xclk_r_REG507_S1 DFFQX1TR $PINS D=n117 CK=clk_clone1 Q=n223
Xclk_r_REG521_S1 DFFQX1TR $PINS D=n111 CK=clk_clone1 Q=n217
Xclk_r_REG520_S1 DFFQX1TR $PINS D=n110 CK=clk_clone1 Q=n216
Xclk_r_REG518_S1 DFFQX1TR $PINS D=n108 CK=clk_clone1 Q=n214
Xclk_r_REG516_S2 DFFQX1TR $PINS D=n298 CK=clk Q=n200
Xclk_r_REG571_S2 DFFQX1TR $PINS D=n307 CK=clk_clone2 Q=n206
Xclk_r_REG553_S1 DFFQX1TR $PINS D=n155 CK=clk_clone1 Q=n261
Xclk_r_REG562_S1 DFFQX1TR $PINS D=n144 CK=clk_clone3 Q=n250
Xclk_r_REG531_S1 DFFQX1TR $PINS D=n173 CK=clk_clone1 Q=n279
Xclk_r_REG543_S1 DFFQX1TR $PINS D=n165 CK=clk_clone1 Q=n271
Xclk_r_REG542_S1 DFFQX1TR $PINS D=n164 CK=clk_clone1 Q=n270
Xclk_r_REG564_S1 DFFQX1TR $PINS D=n146 CK=clk_clone1 Q=n252
Xclk_r_REG532_S1 DFFQX1TR $PINS D=n174 CK=clk_clone1 Q=n280
Xclk_r_REG554_S1 DFFQX1TR $PINS D=n156 CK=clk_clone1 Q=n262
Xclk_r_REG530_S1 DFFQX1TR $PINS D=n172 CK=clk_clone2 Q=n278
Xclk_r_REG541_S1 DFFQX1TR $PINS D=n163 CK=clk_clone1 Q=n269
Xclk_r_REG552_S1 DFFQX1TR $PINS D=n154 CK=clk_clone1 Q=n260
Xclk_r_REG563_S1 DFFQX1TR $PINS D=n145 CK=clk_clone3 Q=n251
Xclk_r_REG529_S1 DFFQX1TR $PINS D=n171 CK=clk_clone3 Q=n277
Xclk_r_REG540_S1 DFFQX1TR $PINS D=n162 CK=clk_clone1 Q=n268
Xclk_r_REG551_S1 DFFQX1TR $PINS D=n153 CK=clk_clone1 Q=n259
XU3 AO22X1TR $PINS A0=n41 A1=n56 B0=n72 B1=n227 Y=n121
XU4 AO22X1TR $PINS A0=n41 A1=n57 B0=n72 B1=n236 Y=n130
XU5 AO22X1TR $PINS A0=n41 A1=n59 B0=n72 B1=n254 Y=n148
XU6 AO22X1TR $PINS A0=n41 A1=n60 B0=n72 B1=n263 Y=n157
XU7 AO22X1TR $PINS A0=n41 A1=n62 B0=n72 B1=n281 Y=n175
XU8 AO22X1TR $PINS A0=n41 A1=FE_DBTN10_reset B0=n72 B1=n292 Y=n186
XU11 NOR2BX2TR $PINS AN=wrb_data<1> B=reset Y=n56
XU12 NOR2BX2TR $PINS AN=wrb_data<2> B=reset Y=n57
XU13 NOR2BX2TR $PINS AN=wrb_data<0> B=reset Y=n35
XU15 NAND2X1TR $PINS A=n92 B=n91 Y=n94
XU17 NAND2X1TR $PINS A=wrb B=n54 Y=n45
XU18 OAI2BB1X1TR $PINS A0N=n210 A1N=n209 B0=n22 Y=n24
XU19 NOR2X1TR $PINS A=reset B=rdb_addr<3> Y=n19
XU21 INVX2TR $PINS A=FE_OFN39_pe_in_pk_wrb_addr__1 Y=n42
XU24 NOR2BX2TR $PINS AN=wrb_data<3> B=FE_OFN29_reset Y=n58
XU25 AO22X1TR $PINS A0=n41 A1=n35 B0=n72 B1=n218 Y=n112
XU26 AO22X1TR $PINS A0=n41 A1=n58 B0=n72 B1=n245 Y=n139
XU27 AO22X1TR $PINS A0=n41 A1=n61 B0=n72 B1=n272 Y=n166
XU28 INVX2TR $PINS A=n44 Y=n73
XU29 INVX2TR $PINS A=n41 Y=n72
XU31 INVX1TR $PINS A=n105 Y=n9
XU33 NAND2X1TR $PINS A=n23 B=n196 Y=data_out<2>
XU35 INVX1TR $PINS A=n249 Y=n93
XU39 OR2X2TR $PINS A=n27 B=n26 Y=n2
XU40 INVX2TR $PINS A=n52 Y=n74
XU41 AOI22X1TR $PINS A0=FE_OFN35_n29 A1=n291 B0=FE_OFN26_FE_DBTN5_n3 B1=n292
+ Y=n32
XU42 NAND2X1TR $PINS A=FE_OFN26_FE_DBTN5_n3 B=n294 Y=n21
XU44 NOR2X4TR $PINS A=rdb_addr<1> B=n27 Y=n29
XU45 OAI2BB1X1TR $PINS A0N=n25 A1N=n293 B0=n30 Y=n31
XU46 INVX2TR $PINS A=wrb_addr<3> Y=n54
XU47 OR2X2TR $PINS A=n33 B=n15 Y=n14
XU48 NAND2BX1TR $PINS AN=FE_DBTN8_pe_in_pk_rdb_addr__2 B=n21 Y=n20
XU50 NOR2X2TR $PINS A=FE_OFN34_n25 B=n10 Y=n105
XU51 NAND3X1TR $PINS A=FE_OFN23_FE_DBTN10_reset B=n288 C=n11 Y=n10
XU53 AND2X2TR $PINS A=FE_DBTN8_pe_in_pk_rdb_addr__2 B=rdb_addr<3> Y=n11
XU54 NAND2X1TR $PINS A=n17 B=FE_DBTN8_pe_in_pk_rdb_addr__2 Y=n15
XU55 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n286 B0=n29 B1=n289 Y=n30
XU56 NOR3X1TR $PINS A=wrb_addr<1> B=wrb_addr<2> C=wrb_addr<0> Y=n50
XU57 NAND2X1TR $PINS A=n24 B=n191 Y=data_out<6>
XU58 AOI2BB2X1TR $PINS A0N=n93 A1N=n9 B0=n104 B1=n94 Y=n305
XU59 AOI22X1TR $PINS A0=n105 A1=n267 B0=n104 B1=n84 Y=n311
XU60 AOI22X1TR $PINS A0=n104 A1=n87 B0=n276 B1=n105 Y=n314
XU61 NOR2BX2TR $PINS AN=wrb_data<4> B=reset Y=n59
XU62 NOR2BX1TR $PINS AN=wrb_data<5> B=FE_OFN29_reset Y=n60
XU63 NOR2BX2TR $PINS AN=wrb_data<6> B=FE_OFN9_reset Y=n61
XU64 NOR2BX2TR $PINS AN=wrb_data<7> B=FE_OFN9_reset Y=n62
XU65 OR2X2TR $PINS A=rdb_addr<0> B=n26 Y=n3
XU71 AND2X6TR $PINS A=n78 B=FE_DBTN8_pe_in_pk_rdb_addr__2 Y=n104
XU72 AND2X4TR $PINS A=n18 B=n14 Y=n78
XU73 NAND2X1TR $PINS A=n287 B=n25 Y=n17
XU74 OA21XLTR $PINS A0=n31 A1=n20 B0=n19 Y=n18
XU76 OAI2BB1X1TR $PINS A0N=n202 A1N=n201 B0=n22 Y=n23
XU77 INVX2TR $PINS A=n213 Y=n22
XU79 OAI2BB1X1TR $PINS A0N=FE_OFN0_FE_DBTN6_n2 A1N=n290 B0=n32 Y=n33
XU80 NAND2X1TR $PINS A=rdb_addr<2> B=n78 Y=n316
XU81 AOI32X4TR $PINS A0=n197 A1=n189 A2=n198 B0=n213 B1=n189 Y=data_out<0>
XU82 AOI32X1TR $PINS A0=n211 A1=n192 A2=n212 B0=n213 B1=n192 Y=data_out<7>
XU83 AOI32X1TR $PINS A0=n207 A1=n190 A2=n208 B0=n213 B1=n190 Y=data_out<5>
XU84 AOI32X1TR $PINS A0=n199 A1=n195 A2=n200 B0=n213 B1=n195 Y=data_out<1>
XU85 AOI32X4TR $PINS A0=n203 A1=n193 A2=n204 B0=n213 B1=n193 Y=data_out<3>
XU86 AOI32X4TR $PINS A0=n205 A1=n194 A2=n206 B0=n213 B1=n194 Y=data_out<4>
XU87 NAND3X1TR $PINS A=wrb B=wrb_addr<0> C=n54 Y=n38
XU89 OAI31X4TR $PINS A0=wrb_addr<1> A1=FE_OFN52_pe_in_pk_wrb_addr__2 A2=n38
+ B0=FE_DBTN10_reset Y=n34
XU90 INVX2TR $PINS A=n34 Y=n69
XU91 AO22X1TR $PINS A0=n34 A1=n35 B0=n69 B1=n214 Y=n108
XU92 NAND2X1TR $PINS A=wrb_addr<1> B=wrb_addr<2> Y=n51
XU93 OAI21X1TR $PINS A0=n51 A1=n38 B0=FE_DBTN10_reset Y=n36
XU95 AO22X1TR $PINS A0=n36 A1=n35 B0=n64 B1=n215 Y=n109
XU96 OAI31X4TR $PINS A0=FE_OFN33_pe_in_pk_wrb_addr__2 A1=n42 A2=n38
+ B0=FE_OFN23_FE_DBTN10_reset Y=n37
XU97 INVX2TR $PINS A=n37 Y=n70
XU98 AO22X1TR $PINS A0=n37 A1=n35 B0=n70 B1=n216 Y=n110
XU99 OAI31X4TR $PINS A0=wrb_addr<1> A1=n38 A2=wrb_addr<2> B0=FE_DBTN10_reset
+ Y=n39
XU100 INVX2TR $PINS A=n39 Y=n71
XU101 AO22X1TR $PINS A0=n39 A1=n35 B0=n71 B1=n217 Y=n111
XU102 NAND2BX1TR $PINS AN=wrb_addr<0> B=FE_OFN52_pe_in_pk_wrb_addr__2 Y=n46
XU103 OAI31X4TR $PINS A0=n42 A1=n46 A2=n45 B0=FE_OFN23_FE_DBTN10_reset Y=n41
XU104 NAND2X1TR $PINS A=FE_OFN33_pe_in_pk_wrb_addr__2 B=n42 Y=n43
XU105 OAI31X4TR $PINS A0=wrb_addr<0> A1=n45 A2=n43 B0=FE_OFN23_FE_DBTN10_reset
+ Y=n44
XU106 AO22X1TR $PINS A0=n44 A1=n35 B0=n73 B1=n219 Y=n113
XU107 OAI31X4TR $PINS A0=FE_OFN39_pe_in_pk_wrb_addr__1 A1=n46 A2=n45
+ B0=FE_OFN23_FE_DBTN10_reset Y=n47
XU108 AO22X1TR $PINS A0=n47 A1=n35 B0=n66 B1=n220 Y=n114
XU109 OAI21X1TR $PINS A0=n50 A1=n54 B0=wrb Y=n53
XU110 OAI31X4TR $PINS A0=wrb_addr<0> A1=n53 A2=n51 B0=FE_DBTN10_reset Y=n52
XU111 AO22X1TR $PINS A0=n52 A1=n35 B0=n74 B1=n221 Y=n115
XU112 OAI21X2TR $PINS A0=n54 A1=n53 B0=FE_DBTN10_reset Y=n55
XU114 INVX2TR $PINS A=n55 Y=n67
XU115 AO22X1TR $PINS A0=n55 A1=n35 B0=n67 B1=n222 Y=n116
XU116 AO22X1TR $PINS A0=n34 A1=n56 B0=n69 B1=n223 Y=n117
XU117 AO22X1TR $PINS A0=n36 A1=n56 B0=n64 B1=n224 Y=n118
XU118 AO22X1TR $PINS A0=n37 A1=n56 B0=n70 B1=n225 Y=n119
XU119 AO22X1TR $PINS A0=n39 A1=n56 B0=n71 B1=n226 Y=n120
XU120 AO22X1TR $PINS A0=n44 A1=n56 B0=n73 B1=n228 Y=n122
XU121 AO22X1TR $PINS A0=n47 A1=n56 B0=n66 B1=n229 Y=n123
XU122 AO22X1TR $PINS A0=n52 A1=n56 B0=n74 B1=n230 Y=n124
XU123 AO22X1TR $PINS A0=n55 A1=n56 B0=n67 B1=n231 Y=n125
XU124 AO22X1TR $PINS A0=n34 A1=n57 B0=n69 B1=n232 Y=n126
XU125 AO22X1TR $PINS A0=n36 A1=n57 B0=n64 B1=n233 Y=n127
XU126 AO22X1TR $PINS A0=n37 A1=n57 B0=n70 B1=n234 Y=n128
XU127 AO22X1TR $PINS A0=n39 A1=n57 B0=n71 B1=n235 Y=n129
XU128 AO22X1TR $PINS A0=n44 A1=n57 B0=n73 B1=n237 Y=n131
XU129 AO22X1TR $PINS A0=n47 A1=n57 B0=n66 B1=n238 Y=n132
XU130 AO22X1TR $PINS A0=n52 A1=n57 B0=n74 B1=n239 Y=n133
XU131 AO22X1TR $PINS A0=n55 A1=n57 B0=n67 B1=n240 Y=n134
XU132 AO22X1TR $PINS A0=n34 A1=n58 B0=n69 B1=n241 Y=n135
XU133 AO22X1TR $PINS A0=n36 A1=n58 B0=n64 B1=n242 Y=n136
XU134 AO22X1TR $PINS A0=n37 A1=n58 B0=n70 B1=n243 Y=n137
XU135 AO22X1TR $PINS A0=n39 A1=n58 B0=n71 B1=n244 Y=n138
XU136 AO22X1TR $PINS A0=n44 A1=n58 B0=n73 B1=n246 Y=n140
XU137 AO22X1TR $PINS A0=n47 A1=n58 B0=n66 B1=n247 Y=n141
XU138 AO22X1TR $PINS A0=n52 A1=n58 B0=n74 B1=n248 Y=n142
XU139 AOI2BB2X1TR $PINS A0N=n67 A1N=n58 B0=n93 B1=n67 Y=n143
XU140 AO22X1TR $PINS A0=n34 A1=n59 B0=n69 B1=n250 Y=n144
XU141 AO22X1TR $PINS A0=n36 A1=n59 B0=n64 B1=n251 Y=n145
XU142 AO22X1TR $PINS A0=n37 A1=n59 B0=n70 B1=n252 Y=n146
XU143 AO22X1TR $PINS A0=n39 A1=n59 B0=n71 B1=n253 Y=n147
XU144 AO22X1TR $PINS A0=n44 A1=n59 B0=n73 B1=n255 Y=n149
XU145 AO22X1TR $PINS A0=n47 A1=n59 B0=n66 B1=n256 Y=n150
XU146 AO22X1TR $PINS A0=n52 A1=n59 B0=n74 B1=n257 Y=n151
XU147 AO22X1TR $PINS A0=n55 A1=n59 B0=n67 B1=n258 Y=n152
XU148 AO22X1TR $PINS A0=n34 A1=n60 B0=n69 B1=n259 Y=n153
XU149 AO22X1TR $PINS A0=n36 A1=n60 B0=n64 B1=n260 Y=n154
XU150 AO22X1TR $PINS A0=n37 A1=n60 B0=n70 B1=n261 Y=n155
XU151 AO22X1TR $PINS A0=n39 A1=n60 B0=n71 B1=n262 Y=n156
XU152 AO22X1TR $PINS A0=n44 A1=n60 B0=n73 B1=n264 Y=n158
XU153 AO22X1TR $PINS A0=n47 A1=n60 B0=n66 B1=n265 Y=n159
XU154 AO22X1TR $PINS A0=n52 A1=n60 B0=n74 B1=n266 Y=n160
XU155 AO22X1TR $PINS A0=n55 A1=n60 B0=n67 B1=n267 Y=n161
XU156 AO22X1TR $PINS A0=n34 A1=n61 B0=n69 B1=n268 Y=n162
XU157 AO22X1TR $PINS A0=n36 A1=n61 B0=n64 B1=n269 Y=n163
XU158 AO22X1TR $PINS A0=n37 A1=n61 B0=n70 B1=n270 Y=n164
XU159 AO22X1TR $PINS A0=n39 A1=n61 B0=n71 B1=n271 Y=n165
XU160 AO22X1TR $PINS A0=n44 A1=n61 B0=n73 B1=n273 Y=n167
XU161 AO22X1TR $PINS A0=n47 A1=n61 B0=n66 B1=n274 Y=n168
XU162 AO22X1TR $PINS A0=n52 A1=n61 B0=n74 B1=n275 Y=n169
XU163 AO22X1TR $PINS A0=n55 A1=n61 B0=n67 B1=n276 Y=n170
XU164 AO22X1TR $PINS A0=n34 A1=n62 B0=n69 B1=n277 Y=n171
XU165 AO22X1TR $PINS A0=n36 A1=n62 B0=n64 B1=n278 Y=n172
XU166 AO22X1TR $PINS A0=n37 A1=n62 B0=n70 B1=n279 Y=n173
XU167 AO22X1TR $PINS A0=n39 A1=n62 B0=n71 B1=n280 Y=n174
XU168 AO22X1TR $PINS A0=n44 A1=n62 B0=n73 B1=n282 Y=n176
XU169 AO22X1TR $PINS A0=n47 A1=n62 B0=n66 B1=n283 Y=n177
XU170 AO22X1TR $PINS A0=n52 A1=n62 B0=n74 B1=n284 Y=n178
XU171 AO22X1TR $PINS A0=n55 A1=n62 B0=n67 B1=n285 Y=n179
XU172 AO22X1TR $PINS A0=n36 A1=FE_DBTN10_reset B0=n64 B1=n286 Y=n180
XU173 AO22X1TR $PINS A0=n47 A1=FE_OFN23_FE_DBTN10_reset B0=FE_OFN56_n47 B1=n287
+ Y=n181
XU174 AO22X1TR $PINS A0=n55 A1=FE_OFN23_FE_DBTN10_reset B0=n67 B1=n288 Y=n182
XU175 AO22X1TR $PINS A0=n34 A1=FE_DBTN10_reset B0=n69 B1=n289 Y=n183
XU176 AO22X1TR $PINS A0=n37 A1=FE_DBTN10_reset B0=n70 B1=n290 Y=n184
XU177 AO22X1TR $PINS A0=n39 A1=FE_DBTN10_reset B0=n71 B1=n291 Y=n185
XU178 AO22X1TR $PINS A0=n44 A1=FE_OFN23_FE_DBTN10_reset B0=n73 B1=n293 Y=n187
XU179 AO22X1TR $PINS A0=n52 A1=FE_OFN23_FE_DBTN10_reset B0=n74 B1=n294 Y=n188
XU180 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n216 B0=FE_OFN35_n29 B1=n217
+ Y=n80
XU181 AOI22X1TR $PINS A0=n13 A1=n220 B0=FE_DBTN5_n3 B1=n218 Y=n79
XU182 NAND2X1TR $PINS A=n80 B=n79 Y=n81
XU183 AOI22X1TR $PINS A0=n105 A1=n222 B0=n104 B1=n81 Y=n296
XU184 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n261 B0=FE_OFN35_n29 B1=n262
+ Y=n83
XU185 AOI22X1TR $PINS A0=n13 A1=n265 B0=FE_DBTN5_n3 B1=n263 Y=n82
XU186 NAND2X1TR $PINS A=n83 B=n82 Y=n84
XU187 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n270 B0=FE_OFN35_n29 B1=n271
+ Y=n86
XU188 AOI22X1TR $PINS A0=n13 A1=n274 B0=FE_DBTN5_n3 B1=n272 Y=n85
XU189 NAND2X1TR $PINS A=n86 B=n85 Y=n87
XU190 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n279 B0=FE_OFN35_n29 B1=n280
+ Y=n89
XU191 AOI22X1TR $PINS A0=n13 A1=n283 B0=FE_DBTN5_n3 B1=n281 Y=n88
XU192 NAND2X1TR $PINS A=n89 B=n88 Y=n90
XU193 AOI22X1TR $PINS A0=n105 A1=n285 B0=n104 B1=n90 Y=n318
XU194 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n243 B0=FE_OFN35_n29 B1=n244
+ Y=n92
XU195 AOI22X1TR $PINS A0=n13 A1=n247 B0=FE_DBTN5_n3 B1=n245 Y=n91
XU196 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n252 B0=FE_OFN35_n29 B1=n253
+ Y=n96
XU197 AOI22X1TR $PINS A0=n13 A1=n256 B0=FE_DBTN5_n3 B1=n254 Y=n95
XU198 NAND2X1TR $PINS A=n96 B=n95 Y=n97
XU199 AOI22X1TR $PINS A0=n105 A1=n258 B0=n104 B1=n97 Y=n308
XU200 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n225 B0=FE_OFN35_n29 B1=n226
+ Y=n99
XU201 AOI22X1TR $PINS A0=n13 A1=n229 B0=FE_DBTN5_n3 B1=n227 Y=n98
XU202 NAND2X1TR $PINS A=n99 B=n98 Y=n100
XU203 AOI22X1TR $PINS A0=n105 A1=n231 B0=n104 B1=n100 Y=n299
XU204 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n234 B0=FE_OFN35_n29 B1=n235
+ Y=n102
XU205 AOI22X1TR $PINS A0=n13 A1=n238 B0=FE_DBTN5_n3 B1=n236 Y=n101
XU206 NAND2X1TR $PINS A=n102 B=n101 Y=n103
XU207 AOI22X1TR $PINS A0=n105 A1=n240 B0=n104 B1=n103 Y=n302
XU208 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n215 B0=n29 B1=n214 Y=n297
XU209 AOI22X1TR $PINS A0=n25 A1=n219 B0=FE_DBTN5_n3 B1=n221 Y=n295
XU210 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n224 B0=n29 B1=n223 Y=n300
XU211 AOI22X1TR $PINS A0=n25 A1=n228 B0=FE_DBTN5_n3 B1=n230 Y=n298
XU212 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n233 B0=n29 B1=n232 Y=n303
XU213 AOI22X1TR $PINS A0=n25 A1=n237 B0=FE_DBTN5_n3 B1=n239 Y=n301
XU214 AOI22X1TR $PINS A0=FE_OFN0_FE_DBTN6_n2 A1=n242 B0=n29 B1=n241 Y=n306
XU215 AOI22X1TR $PINS A0=n25 A1=n246 B0=FE_DBTN5_n3 B1=n248 Y=n304
XU216 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n251 B0=n29 B1=n250 Y=n309
XU217 AOI22X1TR $PINS A0=n25 A1=n255 B0=FE_DBTN5_n3 B1=n257 Y=n307
XU218 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n260 B0=n29 B1=n259 Y=n312
XU219 AOI22X1TR $PINS A0=n25 A1=n264 B0=FE_DBTN5_n3 B1=n266 Y=n310
XU220 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n269 B0=n29 B1=n268 Y=n315
XU221 AOI22X1TR $PINS A0=n25 A1=n273 B0=FE_DBTN5_n3 B1=n275 Y=n313
XU222 AOI22X1TR $PINS A0=FE_DBTN6_n2 A1=n278 B0=n29 B1=n277 Y=n319
XU223 AOI22X1TR $PINS A0=n25 A1=n282 B0=FE_DBTN5_n3 B1=n284 Y=n317
XU66 NOR2X2TR $PINS A=rdb_addr<0> B=rdb_addr<1> Y=n25
Xclk_r_REG496_S1 DFFQX1TR $PINS D=n299 CK=clk Q=n195
Xclk_r_REG498_S1 DFFQX1TR $PINS D=n308 CK=clk_clone2 Q=n194
.ENDS

.SUBCKT MULT_single_2 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> B<7> B<6>
+ B<5> B<4> B<3> B<2> B<1> B<0> data_out<7> data_out<6> data_out<5> data_out<4>
+ data_out<3> data_out<2> data_out<1> data_out<0> clk_clone3 clk_clone2
+ clk_clone1 clk
XPLACEDFE_OFC16_n4 CLKBUFX2TR $PINS A=A<3> Y=FE_OFN16_n4
Xclk_r_REG495_S2 DFFQX1TR $PINS D=B<0> CK=clk Q=n258
Xclk_r_REG486_S2 DFFQX1TR $PINS D=n272 CK=clk Q=n257
Xclk_r_REG472_S2 DFFQX1TR $PINS D=n155 CK=clk Q=n254
Xclk_r_REG456_S2 DFFQX1TR $PINS D=n156 CK=clk Q=n253
Xclk_r_REG477_S3 DFFQX1TR $PINS D=n265 CK=clk_clone2 Q=n249
Xclk_r_REG433_S3 DFFQX1TR $PINS D=n164 CK=clk_clone1 Q=n248
Xclk_r_REG432_S3 DFFQX1TR $PINS D=n80 CK=clk_clone1 Q=n247
Xclk_r_REG440_S3 DFFQX1TR $PINS D=n263 CK=clk_clone2 Q=n244
Xclk_r_REG447_S3 DFFQX4TR $PINS D=n266 CK=clk_clone2 Q=n239
Xclk_r_REG435_S2 DFFQX1TR $PINS D=n181 CK=clk Q=n238
Xclk_r_REG439_S2 DFFQX1TR $PINS D=n180 CK=clk Q=n237
Xclk_r_REG444_S2 DFFQX1TR $PINS D=n182 CK=clk Q=n236
Xclk_r_REG449_S2 DFFQX1TR $PINS D=n179 CK=clk Q=n235
Xclk_r_REG452_S2 DFFQX1TR $PINS D=n271 CK=clk Q=n233
Xclk_r_REG483_S2 DFFQX1TR $PINS D=n161 CK=clk Q=n232
Xclk_r_REG431_S3 DFFQX1TR $PINS D=n165 CK=clk_clone1 Q=n231
Xclk_r_REG448_S3 DFFQX1TR $PINS D=n261 CK=clk_clone2 Q=n229
Xclk_r_REG475_S2 DFFQX1TR $PINS D=n176 CK=clk Q=n228
Xclk_r_REG454_S2 DFFQX1TR $PINS D=n154 CK=clk Q=n226
Xclk_r_REG476_S2 DFFQX1TR $PINS D=n177 CK=clk Q=n225
Xclk_r_REG465_S2 DFFQX1TR $PINS D=n186 CK=clk_clone1 Q=n223
Xclk_r_REG459_S2 DFFQX1TR $PINS D=n168 CK=clk Q=n220
Xclk_r_REG460_S2 DFFQX1TR $PINS D=n167 CK=clk Q=n219
Xclk_r_REG468_S2 DFFQX1TR $PINS D=n145 CK=clk Q=n218
Xclk_r_REG478_S2 DFFQX1TR $PINS D=n174 CK=clk Q=n215
Xclk_r_REG479_S2 DFFQX1TR $PINS D=n175 CK=clk Q=n214
Xclk_r_REG480_S2 DFFQX1TR $PINS D=n173 CK=clk Q=n213
Xclk_r_REG462_S2 DFFQX1TR $PINS D=n184 CK=clk Q=n211
Xclk_r_REG470_S2 DFFQX1TR $PINS D=n169 CK=clk Q=n210
Xclk_r_REG430_S2 DFFQX1TR $PINS D=n162 CK=clk Q=n209
Xclk_r_REG458_S3 DFFQX1TR $PINS D=n268 CK=clk_clone1 Q=n207
Xclk_r_REG484_S2 DFFQX1TR $PINS D=n170 CK=clk Q=n206
Xclk_r_REG445_S3 DFFQX2TR $PINS D=n269 CK=clk Q=n251
Xclk_r_REG450_S2 DFFQX1TR $PINS D=n178 CK=clk Q=n234
Xclk_r_REG446_S3 DFFQX1TR $PINS D=n270 CK=clk_clone2 Q=n250
Xclk_r_REG453_S3 DFFQX1TR $PINS D=n205 CK=clk_clone2 Q=n255
Xclk_r_REG457_S2 DFFQX1TR $PINS D=n183 CK=clk_clone1 Q=n221
Xclk_r_REG442_S3 DFFQX1TR $PINS D=n147 CK=clk_clone3 Q=n246
Xclk_r_REG441_S3 DFFQX1TR $PINS D=n264 CK=clk_clone2 Q=n243
Xclk_r_REG437_S3 DFFQX1TR $PINS D=n150 CK=clk_clone2 Q=n242
Xclk_r_REG451_S3 DFFQX1TR $PINS D=n79 CK=clk_clone1 Q=n230
Xclk_r_REG461_S2 DFFQX1TR $PINS D=n166 CK=clk Q=n208
Xclk_r_REG597_S2 DFFQX1TR $PINS D=n193 CK=clk_clone2 Q=n256
Xclk_r_REG464_S2 DFFQX1TR $PINS D=n187 CK=clk_clone1 Q=n224
Xclk_r_REG467_S2 DFFQX1TR $PINS D=n185 CK=clk Q=n222
Xclk_r_REG469_S2 DFFQX1TR $PINS D=n188 CK=clk Q=n217
Xclk_r_REG466_S2 DFFQX1TR $PINS D=n146 CK=clk Q=n227
Xclk_r_REG481_S2 DFFQX1TR $PINS D=n171 CK=clk_clone1 Q=n216
Xclk_r_REG436_S3 DFFQX1TR $PINS D=n262 CK=clk_clone2 Q=n240
Xclk_r_REG482_S2 DFFQX1TR $PINS D=n172 CK=clk_clone1 Q=n212
Xclk_r_REG595_S1 DFFQX1TR $PINS D=reset CK=clk_clone2 Q=n260
Xclk_r_REG443_S3 DFFQX1TR $PINS D=n148 CK=clk_clone3 Q=n245
Xclk_r_REG596_S2 DFFQX1TR $PINS D=n260 CK=clk_clone2 Q=n259
Xclk_r_REG434_S3 DFFQX1TR $PINS D=n267 CK=clk_clone1 Q=n252
XU1 XOR2X1TR $PINS A=n89 B=n87 Y=n82
XU2 AOI22X1TR $PINS A0=A<5> A1=n159 B0=B<1> B1=n144 Y=n197
XU3 AOI21X1TR $PINS A0=n220 A1=n217 B0=n121 Y=n87
XU4 INVX2TR $PINS A=B<0> Y=n200
XU5 INVX2TR $PINS A=B<4> Y=n189
XU7 XOR2X1TR $PINS A=n81 B=n209 Y=n90
XU9 INVX2TR $PINS A=A<7> Y=n131
XU11 AND2X2TR $PINS A=n237 B=n210 Y=n64
XU13 INVX2TR $PINS A=n98 Y=n95
XU14 NAND3X1TR $PINS A=n14 B=n13 C=n93 Y=n12
XU16 NAND2X1TR $PINS A=n67 B=n66 Y=n85
XU17 AOI22X1TR $PINS A0=A<5> A1=n189 B0=B<4> B1=n144 Y=n143
XU18 XNOR2X1TR $PINS A=n82 B=n90 Y=n80
XU19 CLKINVX2TR $PINS A=A<0> Y=n50
XU20 INVX1TR $PINS A=n23 Y=n272
XU21 CLKINVX2TR $PINS A=B<6> Y=n149
XU22 INVX1TR $PINS A=n127 Y=n128
XU23 OA21XLTR $PINS A0=n41 A1=n226 B0=n40 Y=n205
XU24 INVX1TR $PINS A=A<1> Y=n46
XU25 INVX1TR $PINS A=n265 Y=n56
XU26 AND2X2TR $PINS A=n234 B=n208 Y=n78
XU29 AND2X6TR $PINS A=n2 B=n98 Y=data_out<5>
XU30 XNOR2X4TR $PINS A=n92 B=n15 Y=n2
XU31 NOR4BX1TR $PINS AN=n55 B=n54 C=n259 D=n260 Y=data_out<0>
XU32 AND3X2TR $PINS A=n102 B=n101 C=n100 Y=n103
XU33 XOR2X1TR $PINS A=n219 B=n232 Y=n124
XU34 XNOR2X1TR $PINS A=n124 B=n123 Y=n267
XU35 AO21X1TR $PINS A0=n23 A1=n204 B0=n113 Y=n161
XU36 OAI22X1TR $PINS A0=n139 A1=n137 B0=n130 B1=n140 Y=n167
XU38 AND2X2TR $PINS A=n9 B=n98 Y=data_out<2>
XU39 AOI31X1TR $PINS A0=A<6> A1=A<5> A2=n131 B0=n127 Y=n139
XU40 INVX2TR $PINS A=A<5> Y=n144
XU41 XOR2X1TR $PINS A=n64 B=n22 Y=n31
XU42 XOR2X1TR $PINS A=n83 B=n85 Y=n68
XU44 NOR2X6TR $PINS A=n95 B=n76 Y=data_out<4>
XU45 AND2X2TR $PINS A=n256 B=n193 Y=n98
XU49 NAND2X1TR $PINS A=n91 B=n93 Y=n15
XU50 INVX1TR $PINS A=n93 Y=n11
XU51 NAND2X1TR $PINS A=n247 B=n230 Y=n93
XU53 AO22X1TR $PINS A0=FE_OFN16_n4 A1=n107 B0=n24 B1=n158 Y=n204
XU54 NOR2X2TR $PINS A=n96 B=n95 Y=data_out<6>
XU55 NOR2X1TR $PINS A=n95 B=n61 Y=data_out<3>
XU56 NOR3X1TR $PINS A=A<5> B=A<6> C=n131 Y=n127
XU57 INVX1TR $PINS A=B<7> Y=n45
XU58 NAND2X1TR $PINS A=n29 B=n30 Y=n91
XU59 INVX1TR $PINS A=n230 Y=n29
XU60 INVX1TR $PINS A=n247 Y=n30
XU61 XNOR2X1TR $PINS A=n252 B=n207 Y=n101
XU62 INVX1TR $PINS A=n231 Y=n97
XU63 NOR3X1TR $PINS A=FE_OFN16_n4 B=A<4> C=n144 Y=n125
XU64 AOI2BB1X1TR $PINS A0N=n208 A1N=n234 B0=n78 Y=n83
XU65 XOR2X1TR $PINS A=n38 B=n37 Y=n43
XU66 OAI21X1TR $PINS A0=n214 A1=n222 B0=n38 Y=n20
XU67 AND2X1TR $PINS A=n236 B=n44 Y=n269
XU68 OAI32X1TR $PINS A0=n158 A1=B<0> A2=n23 B0=n107 B1=n158 Y=n170
XU69 OAI211X1TR $PINS A0=n159 A1=n50 B0=A<1> C0=n200 Y=n154
XU70 AO21X1TR $PINS A0=n90 A1=n89 B0=n88 Y=n165
XU71 NOR2X1TR $PINS A=n32 B=n31 Y=n264
XU72 NAND2X1TR $PINS A=n32 B=n31 Y=n263
XU73 NAND2X2TR $PINS A=n12 B=n10 Y=n102
XU74 INVX2TR $PINS A=n8 Y=n58
XU76 XNOR2X1TR $PINS A=n58 B=n53 Y=n9
XU77 OAI21X2TR $PINS A0=n26 A1=n240 B0=n25 Y=n8
XU78 NAND2X2TR $PINS A=n71 B=n73 Y=n14
XU79 NAND2X2TR $PINS A=n14 B=n13 Y=n92
XU80 OR2X2TR $PINS A=n91 B=n11 Y=n10
XU81 NOR3X1TR $PINS A=n250 B=n251 C=n255 Y=n54
XU82 INVX1TR $PINS A=n125 Y=n48
XU83 XOR2X1TR $PINS A=n86 B=n68 Y=n69
XU84 NOR3X4TR $PINS A=n251 B=n249 C=n239 Y=n26
XU85 NOR2X1TR $PINS A=n229 B=n26 Y=n16
XU86 XOR2X2TR $PINS A=n16 B=n240 Y=n17
XU87 OR2X2TR $PINS A=n17 B=n259 Y=n18
XU88 OR2X2TR $PINS A=n18 B=n260 Y=n19
XU89 CLKINVX4TR $PINS A=n19 Y=data_out<1>
XU90 AOI2BB1X1TR $PINS A0N=n237 A1N=n210 B0=n64 Y=n38
XU91 OAI2BB1X1TR $PINS A0N=n222 A1N=n214 B0=n20 Y=n32
XU92 XOR2X1TR $PINS A=n227 B=n253 Y=n21
XU93 XOR2X1TR $PINS A=n21 B=n215 Y=n62
XU94 XOR2X1TR $PINS A=n235 B=n62 Y=n22
XU95 NAND2X1TR $PINS A=A<2> B=A<1> Y=n24
XU96 OAI21X1TR $PINS A0=A<2> A1=A<1> B0=n24 Y=n23
XU98 OR2X1TR $PINS A=A<2> B=A<1> Y=n107
XU99 OAI22X1TR $PINS A0=n158 A1=n45 B0=B<7> B1=FE_OFN16_n4 Y=n113
XU100 CLKINVX2TR $PINS A=n229 Y=n25
XU101 NOR2X1TR $PINS A=n243 B=n242 Y=n27
XU102 CLKINVX2TR $PINS A=n246 Y=n73
XU103 OAI21X1TR $PINS A0=n243 A1=n241 B0=n244 Y=n72
XU104 NOR2X1TR $PINS A=n221 B=n216 Y=n115
XU105 AOI21X1TR $PINS A0=n216 A1=n221 B0=n115 Y=n34
XU106 INVX1TR $PINS A=n223 Y=n33
XU107 XOR2X1TR $PINS A=n34 B=n33 Y=n118
XU108 OAI21X1TR $PINS A0=n209 A1=n212 B0=n78 Y=n35
XU109 OAI2BB1X1TR $PINS A0N=n212 A1N=n209 B0=n35 Y=n116
XU110 OR2X2TR $PINS A=n217 B=n220 Y=n117
XU111 XOR2X1TR $PINS A=n116 B=n117 Y=n36
XU112 XOR2X1TR $PINS A=n118 B=n36 Y=n164
XU113 XOR2X1TR $PINS A=n214 B=n222 Y=n37
XU114 OAI21X1TR $PINS A0=n238 A1=n254 B0=n228 Y=n39
XU115 OAI2BB1X1TR $PINS A0N=n254 A1N=n238 B0=n39 Y=n42
XU116 NOR2X1TR $PINS A=n43 B=n42 Y=n150
XU117 AOI2BB1X1TR $PINS A0N=n206 A1N=n225 B0=n265 Y=n44
XU118 NOR2X1TR $PINS A=n236 B=n44 Y=n270
XU119 AOI21X1TR $PINS A0=n257 A1=n258 B0=n233 Y=n41
XU120 NAND3X1TR $PINS A=n258 B=n257 C=n233 Y=n40
XU121 NOR2X1TR $PINS A=n270 B=n205 Y=n266
XU122 NAND2X1TR $PINS A=n43 B=n42 Y=n151
XU123 AOI32X1TR $PINS A0=B<7> A1=n46 A2=A<0> B0=n45 B1=A<1> Y=n162
XU124 NAND2X1TR $PINS A=FE_OFN16_n4 B=A<4> Y=n47
XU125 OAI21X1TR $PINS A0=FE_OFN16_n4 A1=A<4> B0=n47 Y=n199
XU126 OAI31X1TR $PINS A0=n199 A1=n144 A2=B<0> B0=n48 Y=n169
XU127 NAND2X1TR $PINS A=A<1> B=A<0> Y=n195
XU128 NOR2X1TR $PINS A=A<1> B=n50 Y=n191
XU129 AND2X2TR $PINS A=n50 B=A<1> Y=n190
XU130 CLKINVX2TR $PINS A=B<3> Y=n129
XU131 AOI22X1TR $PINS A0=B<4> A1=n191 B0=n190 B1=n129 Y=n51
XU132 OAI21X1TR $PINS A0=B<4> A1=n195 B0=n51 Y=n181
XU133 AOI22X1TR $PINS A0=n191 A1=B<2> B0=n190 B1=n159 Y=n52
XU134 OAI21X1TR $PINS A0=B<2> A1=n195 B0=n52 Y=n271
XU135 NOR2BX1TR $PINS AN=n241 B=n242 Y=n53
XU136 OAI21X1TR $PINS A0=n250 A1=n251 B0=n255 Y=n55
XU137 NOR3BX1TR $PINS AN=n236 B=n205 C=n56 Y=n261
XU138 XOR2X1TR $PINS A=n254 B=n228 Y=n57
XU139 XNOR2X1TR $PINS A=n57 B=n238 Y=n262
XU140 NAND2BX1TR $PINS AN=n243 B=n244 Y=n60
XU141 OAI21X1TR $PINS A0=n242 A1=n58 B0=n241 Y=n59
XU142 XOR2X1TR $PINS A=n60 B=n59 Y=n61
XU143 OAI21X1TR $PINS A0=n64 A1=n235 B0=n62 Y=n63
XU144 OAI2BB1X1TR $PINS A0N=n235 A1N=n64 B0=n63 Y=n70
XU145 XOR2X1TR $PINS A=n218 B=n211 Y=n65
XU146 XOR2X1TR $PINS A=n213 B=n65 Y=n86
XU147 OAI21X1TR $PINS A0=n227 A1=n253 B0=n215 Y=n67
XU148 NAND2X1TR $PINS A=n227 B=n253 Y=n66
XU149 NAND2X1TR $PINS A=n70 B=n69 Y=n148
XU150 NOR2X1TR $PINS A=n70 B=n69 Y=n147
XU151 NOR2X2TR $PINS A=n72 B=n71 Y=n75
XU152 NAND2X1TR $PINS A=n73 B=n245 Y=n74
XU153 XNOR2X4TR $PINS A=n75 B=n74 Y=n76
XU154 OAI21X1TR $PINS A0=n213 A1=n218 B0=n211 Y=n77
XU155 OAI2BB1X1TR $PINS A0N=n218 A1N=n213 B0=n77 Y=n89
XU156 INVX1TR $PINS A=n117 Y=n121
XU157 XOR2X1TR $PINS A=n212 B=n78 Y=n81
XU158 OAI21X1TR $PINS A0=n86 A1=n85 B0=n83 Y=n84
XU159 OAI2BB1X1TR $PINS A0N=n86 A1N=n85 B0=n84 Y=n79
XU160 AOI2BB1X1TR $PINS A0N=n90 A1N=n89 B0=n87 Y=n88
XU161 NOR2X1TR $PINS A=n231 B=n248 Y=n99
XU162 NAND2X1TR $PINS A=n231 B=n248 Y=n100
XU163 NAND2BX1TR $PINS AN=n99 B=n100 Y=n94
XU164 XNOR2X2TR $PINS A=n102 B=n94 Y=n96
XU165 OAI21X1TR $PINS A0=n101 A1=n97 B0=n248 Y=n106
XU166 AO21X1TR $PINS A0=n101 A1=n97 B0=n248 Y=n105
XU167 OAI31X1TR $PINS A0=n101 A1=n102 A2=n99 B0=n98 Y=n104
XU168 AOI211X1TR $PINS A0=n106 A1=n105 B0=n104 C0=n103 Y=data_out<7>
XU169 AOI22X1TR $PINS A0=B<0> A1=n131 B0=A<7> B1=n200 Y=n109
XU170 AOI22X1TR $PINS A0=A<7> A1=n159 B0=B<1> B1=n131 Y=n132
XU171 NAND2X1TR $PINS A=A<5> B=A<6> Y=n108
XU172 OAI21X1TR $PINS A0=A<5> A1=A<6> B0=n108 Y=n140
XU173 OAI22X1TR $PINS A0=n139 A1=n109 B0=n132 B1=n140 Y=n184
XU174 CLKINVX2TR $PINS A=B<5> Y=n142
XU175 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n142 B0=B<5> B1=n158 Y=n110
XU176 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n149 B0=B<6> B1=n158 Y=n114
XU177 OAI22X1TR $PINS A0=n204 A1=n110 B0=n23 B1=n114 Y=n172
XU178 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n189 B0=B<4> B1=n158 Y=n111
XU179 OAI22X1TR $PINS A0=n204 A1=n111 B0=n23 B1=n110 Y=n173
XU180 CLKINVX2TR $PINS A=B<2> Y=n135
XU181 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n135 B0=B<2> B1=n158 Y=n201
XU182 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n129 B0=B<3> B1=n158 Y=n112
XU183 OAI22X1TR $PINS A0=n204 A1=n201 B0=n23 B1=n112 Y=n175
XU184 OAI22X1TR $PINS A0=n204 A1=n112 B0=n23 B1=n111 Y=n174
XU185 OAI22X1TR $PINS A0=n114 A1=n204 B0=n23 B1=n113 Y=n171
XU186 AOI32X1TR $PINS A0=n216 A1=n223 A2=n221 B0=n115 B1=n33 Y=n268
XU187 INVX2TR $PINS A=n118 Y=n120
XU188 OAI21X1TR $PINS A0=n118 A1=n117 B0=n116 Y=n119
XU189 OAI21X1TR $PINS A0=n121 A1=n120 B0=n119 Y=n122
XU190 XNOR2X1TR $PINS A=n224 B=n122 Y=n123
XU191 AOI31X1TR $PINS A0=FE_OFN16_n4 A1=A<4> A2=n144 B0=n125 Y=n198
XU192 AOI22X1TR $PINS A0=A<5> A1=n129 B0=B<3> B1=n144 Y=n126
XU193 OAI22X1TR $PINS A0=n198 A1=n126 B0=n143 B1=n199 Y=n188
XU194 AOI22X1TR $PINS A0=A<5> A1=n135 B0=B<2> B1=n144 Y=n196
XU195 OAI22X1TR $PINS A0=n198 A1=n196 B0=n199 B1=n126 Y=n145
XU196 OAI31X1TR $PINS A0=n140 A1=n131 A2=B<0> B0=n128 Y=n166
XU197 AOI22X1TR $PINS A0=A<7> A1=n129 B0=B<3> B1=n131 Y=n137
XU198 AOI22X1TR $PINS A0=A<7> A1=n189 B0=B<4> B1=n131 Y=n130
XU199 AOI22X1TR $PINS A0=A<7> A1=n135 B0=B<2> B1=n131 Y=n138
XU200 OAI22X1TR $PINS A0=n139 A1=n132 B0=n138 B1=n140 Y=n168
XU201 AOI22X1TR $PINS A0=B<7> A1=n191 B0=n190 B1=n149 Y=n133
XU202 OAI21X1TR $PINS A0=B<7> A1=n195 B0=n133 Y=n178
XU203 AOI22X1TR $PINS A0=B<6> A1=n191 B0=n190 B1=n142 Y=n134
XU204 OAI21X1TR $PINS A0=B<6> A1=n195 B0=n134 Y=n179
XU205 AOI22X1TR $PINS A0=B<3> A1=n191 B0=n190 B1=n135 Y=n136
XU206 OAI21X1TR $PINS A0=B<3> A1=n195 B0=n136 Y=n182
XU207 OAI22X1TR $PINS A0=n139 A1=n138 B0=n137 B1=n140 Y=n183
XU208 NOR2X1TR $PINS A=n200 B=n140 Y=n156
XU209 AOI22X1TR $PINS A0=B<0> A1=n144 B0=A<5> B1=n200 Y=n141
XU210 OAI22X1TR $PINS A0=n198 A1=n141 B0=n197 B1=n199 Y=n185
XU211 AOI22X1TR $PINS A0=A<5> A1=n142 B0=B<5> B1=n144 Y=n157
XU212 OAI22X1TR $PINS A0=n198 A1=n143 B0=n157 B1=n199 Y=n186
XU213 AOI22X1TR $PINS A0=A<5> A1=n149 B0=B<6> B1=n144 Y=n153
XU214 OAI22X1TR $PINS A0=n198 A1=n157 B0=n153 B1=n199 Y=n187
XU215 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n200 B0=B<0> B1=n158 Y=n163
XU216 AOI22X1TR $PINS A0=FE_OFN16_n4 A1=n159 B0=B<1> B1=n158 Y=n203
XU217 OAI22X1TR $PINS A0=n204 A1=n163 B0=n23 B1=n203 Y=n177
XU218 AOI22X1TR $PINS A0=B<5> A1=n191 B0=n190 B1=n189 Y=n194
XU219 OAI21X1TR $PINS A0=B<5> A1=n195 B0=n194 Y=n180
XU220 OAI22X1TR $PINS A0=n198 A1=n197 B0=n196 B1=n199 Y=n146
XU221 NOR2X1TR $PINS A=n200 B=n199 Y=n155
XU222 OAI22X1TR $PINS A0=n204 A1=n203 B0=n23 B1=n201 Y=n176
XU75 AND2X2TR $PINS A=n27 B=n8 Y=n71
XU37 INVX2TR $PINS A=B<1> Y=n159
Xclk_r_REG438_S3 DFFQX1TR $PINS D=n151 CK=clk_clone2 Q=n241
XU43 NAND2BX1TR $PINS AN=n246 B=n72 Y=n28
XU15 AND2X2TR $PINS A=n28 B=n245 Y=n13
XU6 INVX2TR $PINS A=FE_OFN16_n4 Y=n158
XU27 INVX2TR $PINS A=n260 Y=n193
XU46 AND2X1TR $PINS A=n206 B=n225 Y=n265
.ENDS

.SUBCKT buffer_mult_2 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> wrb_data<7>
+ wrb_data<6> wrb_data<5> wrb_data<4> wrb_data<3> wrb_data<2> wrb_data<1>
+ wrb_data<0> wrb_addr<3> wrb_addr<2> wrb_addr<1> wrb_addr<0> wrb rdb_addr<3>
+ rdb_addr<2> rdb_addr<1> rdb_addr<0> data_out<7> data_out<6> data_out<5>
+ data_out<4> data_out<3> data_out<2> data_out<1> data_out<0> FE_OFN8_reset
+ FE_OFN4_reset FE_OFN2_reset FE_OFN32_pe_in_pk_wrb_addr__2
+ FE_OFN38_pe_in_pk_wrb_addr__1 clk_clone5 clk_clone4 clk_clone3 clk_clone2
+ clk_clone1 clk
Xclk_r_REG471_S1 DFFQX1TR $PINS D=mult_A<4> CK=clk_clone2 Q=n5
Xclk_r_REG485_S1 DFFQX1TR $PINS D=mult_A<2> CK=clk_clone2 Q=n3
Xclk_r_REG487_S1 DFFQX1TR $PINS D=mult_A<1> CK=clk_clone2 Q=n2
Xclk_r_REG473_S1 DFFQX1TR $PINS D=mult_A<7> CK=clk_clone2 Q=n8
Xclk_r_REG474_S1 DFFQX1TR $PINS D=mult_A<3> CK=clk_clone2 Q=n4
Xclk_r_REG463_S1 DFFQX1TR $PINS D=mult_A<5> CK=clk_clone2 Q=n6
Xclk_r_REG429_S1 DFFQX1TR $PINS D=mult_A<0> CK=clk_clone2 Q=n1
Xclk_r_REG455_S1 DFFQX1TR $PINS D=mult_A<6> CK=clk_clone2 Q=n7
XU4 NOR2BX1TR $PINS AN=A<0> B=FE_OFN4_reset Y=mult_A<0>
XU5 NOR2BX1TR $PINS AN=A<1> B=FE_OFN4_reset Y=mult_A<1>
XU6 NOR2BX1TR $PINS AN=A<2> B=FE_OFN4_reset Y=mult_A<2>
XU7 NOR2BX1TR $PINS AN=A<3> B=FE_OFN4_reset Y=mult_A<3>
XU8 NOR2BX1TR $PINS AN=A<4> B=FE_OFN4_reset Y=mult_A<4>
XU9 NOR2BX1TR $PINS AN=A<5> B=FE_OFN4_reset Y=mult_A<5>
XU10 NOR2BX1TR $PINS AN=A<6> B=FE_OFN4_reset Y=mult_A<6>
XU11 NOR2BX1TR $PINS AN=A<7> B=FE_OFN4_reset Y=mult_A<7>
Xbuffer0 buffer_2 $PINS reset=FE_OFN8_reset wrb_data<7>=wrb_data<7>
+ wrb_data<6>=wrb_data<6> wrb_data<5>=wrb_data<5> wrb_data<4>=wrb_data<4>
+ wrb_data<3>=wrb_data<3> wrb_data<2>=wrb_data<2> wrb_data<1>=wrb_data<1>
+ wrb_data<0>=wrb_data<0> wrb_addr<3>=wrb_addr<3> wrb_addr<2>=wrb_addr<2>
+ wrb_addr<1>=wrb_addr<1> wrb_addr<0>=wrb_addr<0> wrb=wrb rdb_addr<3>=rdb_addr<3>
+ rdb_addr<2>=rdb_addr<2> rdb_addr<1>=rdb_addr<1> rdb_addr<0>=rdb_addr<0>
+ data_out<7>=buf_data<7> data_out<6>=buf_data<6> data_out<5>=buf_data<5>
+ data_out<4>=buf_data<4> data_out<3>=buf_data<3> data_out<2>=buf_data<2>
+ data_out<1>=buf_data<1> data_out<0>=buf_data<0> FE_OFN9_reset=reset
+ FE_OFN29_reset=FE_OFN2_reset
+ FE_OFN33_pe_in_pk_wrb_addr__2=FE_OFN32_pe_in_pk_wrb_addr__2
+ FE_OFN39_pe_in_pk_wrb_addr__1=FE_OFN38_pe_in_pk_wrb_addr__1
+ clk_clone3=clk_clone5 clk_clone2=clk_clone4 clk_clone1=clk_clone1 clk=clk
XMULT_single0 MULT_single_2 $PINS reset=FE_OFN8_reset A<7>=n8 A<6>=n7 A<5>=n6
+ A<4>=n5 A<3>=n4 A<2>=n3 A<1>=n2 A<0>=n1 B<7>=buf_data<7> B<6>=buf_data<6>
+ B<5>=buf_data<5> B<4>=buf_data<4> B<3>=buf_data<3> B<2>=buf_data<2>
+ B<1>=buf_data<1> B<0>=buf_data<0> data_out<7>=data_out<7>
+ data_out<6>=data_out<6> data_out<5>=data_out<5> data_out<4>=data_out<4>
+ data_out<3>=data_out<3> data_out<2>=data_out<2> data_out<1>=data_out<1>
+ data_out<0>=data_out<0> clk_clone3=clk_clone5 clk_clone2=clk_clone4
+ clk_clone1=clk_clone3 clk=clk_clone2
.ENDS

.SUBCKT buffer_1 reset wrb_data<7> wrb_data<6> wrb_data<5> wrb_data<4>
+ wrb_data<3> wrb_data<2> wrb_data<1> wrb_data<0> wrb_addr<3> wrb_addr<2>
+ wrb_addr<1> wrb_addr<0> wrb rdb_addr<3> rdb_addr<2> rdb_addr<1> rdb_addr<0>
+ data_out<7> data_out<6> data_out<5> data_out<4> data_out<3> data_out<2>
+ data_out<1> data_out<0> FE_OFN14_reset FE_OFN17_pe_in_pk_wrb_addr__1
+ FE_OFN19_pe_in_pk_wrb_addr__0 clk_clone3 clk_clone2 clk_clone1 clk
XPLACEDFE_OFC116_n63 CLKBUFX2TR $PINS A=n63 Y=FE_OFN37_n63
XPLACEDFE_OFC113_n61 CLKBUFX2TR $PINS A=n61 Y=FE_OFN36_n61
XPLACEDFE_OFC112_n1 INVX2TR $PINS A=n1 Y=FE_DBTN4_n1
XPLACEDFE_OFC111_n1 INVX2TR $PINS A=n1 Y=FE_OFN27_FE_DBTN4_n1
XPLACEDFE_OFC104_pe_in_pk_rdb_addr__2 CLKINVX2TR $PINS A=rdb_addr<2> Y=n69
XPLACEDFE_OFC97_n3 INVX2TR $PINS A=n3 Y=FE_DBTN3_n3
XPLACEDFE_OFC96_n3 INVX2TR $PINS A=n3 Y=FE_OFN28_FE_DBTN3_n3
XPLACEDFE_OFC86_n20 INVX2TR $PINS A=n20 Y=FE_OFN42_n20
XPLACEDFE_OFC85_n20 CLKBUFX2TR $PINS A=n20 Y=n48
XPLACEDFE_OFC81_pe_in_pk_wrb_addr__2 CLKBUFX2TR $PINS A=wrb_addr<2>
+ Y=FE_OFN51_pe_in_pk_wrb_addr__2
XPLACEDFE_OFC71_pe_in_pk_rdb_addr__0 CLKINVX2TR $PINS A=rdb_addr<0> Y=n64
XPLACEDFE_OFC65_reset INVX2TR $PINS A=FE_OFN14_reset Y=FE_OFN49_reset
XPLACEDFE_OFC64_reset CLKINVX2TR $PINS A=FE_OFN14_reset
+ Y=FE_OFN22_FE_DBTN11_reset
XPLACEDFE_OFC63_reset CLKINVX2TR $PINS A=FE_OFN14_reset Y=FE_DBTN11_reset
XPLACEDFE_OFC48_pe_in_pk_rdb_addr__1 CLKINVX2TR $PINS A=rdb_addr<1> Y=n62
Xclk_r_REG157_S1 DFFQX1TR $PINS D=n178 CK=clk_clone2 Q=n284
Xclk_r_REG156_S1 DFFQX1TR $PINS D=n177 CK=clk_clone2 Q=n283
Xclk_r_REG155_S1 DFFQX1TR $PINS D=n176 CK=clk Q=n282
Xclk_r_REG154_S1 DFFQX1TR $PINS D=n175 CK=clk Q=n281
Xclk_r_REG153_S1 DFFQX1TR $PINS D=n174 CK=clk Q=n280
Xclk_r_REG152_S1 DFFQX1TR $PINS D=n173 CK=clk_clone2 Q=n279
Xclk_r_REG169_S1 DFFQX1TR $PINS D=n171 CK=clk Q=n277
Xclk_r_REG200_S1 DFFQX1TR $PINS D=n168 CK=clk_clone2 Q=n274
Xclk_r_REG199_S1 DFFQX1TR $PINS D=n167 CK=clk Q=n273
Xclk_r_REG198_S1 DFFQX1TR $PINS D=n166 CK=clk_clone2 Q=n272
Xclk_r_REG197_S1 DFFQX1TR $PINS D=n165 CK=clk Q=n271
Xclk_r_REG211_S1 DFFQX1TR $PINS D=n159 CK=clk_clone2 Q=n265
Xclk_r_REG210_S1 DFFQX1TR $PINS D=n158 CK=clk Q=n264
Xclk_r_REG209_S1 DFFQX1TR $PINS D=n157 CK=clk_clone2 Q=n263
Xclk_r_REG208_S1 DFFQX1TR $PINS D=n156 CK=clk Q=n262
Xclk_r_REG222_S1 DFFQX1TR $PINS D=n150 CK=clk_clone2 Q=n256
Xclk_r_REG221_S1 DFFQX1TR $PINS D=n149 CK=clk Q=n255
Xclk_r_REG220_S1 DFFQX1TR $PINS D=n148 CK=clk_clone2 Q=n254
Xclk_r_REG219_S1 DFFQX1TR $PINS D=n147 CK=clk Q=n253
Xclk_r_REG233_S1 DFFQX1TR $PINS D=n141 CK=clk_clone2 Q=n247
Xclk_r_REG232_S1 DFFQX1TR $PINS D=n140 CK=clk Q=n246
Xclk_r_REG231_S1 DFFQX1TR $PINS D=n139 CK=clk_clone2 Q=n245
Xclk_r_REG230_S1 DFFQX1TR $PINS D=n138 CK=clk Q=n244
Xclk_r_REG244_S1 DFFQX1TR $PINS D=n132 CK=clk_clone2 Q=n238
Xclk_r_REG243_S1 DFFQX1TR $PINS D=n131 CK=clk Q=n237
Xclk_r_REG242_S1 DFFQX1TR $PINS D=n130 CK=clk_clone2 Q=n236
Xclk_r_REG241_S1 DFFQX1TR $PINS D=n129 CK=clk Q=n235
Xclk_r_REG255_S1 DFFQX1TR $PINS D=n123 CK=clk_clone2 Q=n229
Xclk_r_REG254_S1 DFFQX1TR $PINS D=n122 CK=clk Q=n228
Xclk_r_REG253_S1 DFFQX1TR $PINS D=n121 CK=clk_clone2 Q=n227
Xclk_r_REG252_S1 DFFQX1TR $PINS D=n120 CK=clk Q=n226
Xclk_r_REG178_S1 DFFQX1TR $PINS D=n114 CK=clk_clone2 Q=n220
Xclk_r_REG177_S1 DFFQX1TR $PINS D=n113 CK=clk Q=n219
Xclk_r_REG176_S1 DFFQX1TR $PINS D=n112 CK=clk_clone2 Q=n218
Xclk_r_REG175_S1 DFFQX1TR $PINS D=n111 CK=clk Q=n217
Xclk_r_REG174_S1 DFFQX1TR $PINS D=n110 CK=clk Q=n216
Xclk_r_REG173_S1 DFFQX1TR $PINS D=n109 CK=clk Q=n215
Xclk_r_REG172_S1 DFFQX1TR $PINS D=n108 CK=clk_clone1 Q=n214
Xclk_r_REG171_S1 DFFQX1TR $PINS D=n107 CK=clk_clone1 Q=n213
Xclk_r_REG190_S1 DFFQX1TR $PINS D=n106 CK=clk_clone2 Q=n212
Xclk_r_REG189_S1 DFFQX1TR $PINS D=n105 CK=clk_clone2 Q=n211
Xclk_r_REG188_S1 DFFQX1TR $PINS D=n104 CK=clk Q=n210
Xclk_r_REG187_S1 DFFQX1TR $PINS D=n103 CK=clk_clone2 Q=n209
Xclk_r_REG186_S1 DFFQX1TR $PINS D=n102 CK=clk Q=n208
Xclk_r_REG185_S1 DFFQX1TR $PINS D=n101 CK=clk Q=n207
Xclk_r_REG184_S1 DFFQX1TR $PINS D=n100 CK=clk Q=n206
Xclk_r_REG183_S1 DFFQX1TR $PINS D=n99 CK=clk_clone1 Q=n205
Xclk_r_REG182_S1 DFFQX1TR $PINS D=n98 CK=clk_clone1 Q=n204
Xclk_r_REG202_S2 DFFQX1TR $PINS D=n307 CK=clk_clone2 Q=n202
Xclk_r_REG203_S2 DFFQX1TR $PINS D=n309 CK=clk_clone2 Q=n200
Xclk_r_REG213_S2 DFFQX1TR $PINS D=n303 CK=clk_clone2 Q=n199
Xclk_r_REG214_S2 DFFQX1TR $PINS D=n305 CK=clk_clone2 Q=n197
Xclk_r_REG224_S2 DFFQX1TR $PINS D=n300 CK=clk_clone2 Q=n196
Xclk_r_REG225_S2 DFFQX1TR $PINS D=n302 CK=clk_clone2 Q=n194
Xclk_r_REG235_S2 DFFQX1TR $PINS D=n297 CK=clk_clone2 Q=n193
Xclk_r_REG161_S1 DFFQX1TR $PINS D=n298 CK=clk_clone2 Q=n192
Xclk_r_REG236_S2 DFFQX1TR $PINS D=n299 CK=clk_clone2 Q=n191
Xclk_r_REG246_S2 DFFQX1TR $PINS D=n294 CK=clk_clone2 Q=n190
Xclk_r_REG162_S1 DFFQX1TR $PINS D=n295 CK=clk_clone2 Q=n189
Xclk_r_REG247_S2 DFFQX1TR $PINS D=n296 CK=clk_clone2 Q=n188
Xclk_r_REG257_S2 DFFQX1TR $PINS D=n291 CK=clk_clone2 Q=n187
Xclk_r_REG258_S2 DFFQX1TR $PINS D=n293 CK=clk_clone2 Q=n185
Xclk_r_REG180_S2 DFFQX1TR $PINS D=n288 CK=clk_clone2 Q=n184
Xclk_r_REG181_S2 DFFQX1TR $PINS D=n290 CK=clk_clone2 Q=n182
Xclk_r_REG191_S2 DFFQX1TR $PINS D=n285 CK=clk_clone2 Q=n181
Xclk_r_REG192_S2 DFFQX1TR $PINS D=n287 CK=clk_clone2 Q=n179
Xclk_r_REG206_S1 DFFQX1TR $PINS D=n154 CK=clk Q=n260
Xclk_r_REG248_S1 DFFQX1TR $PINS D=n116 CK=clk_clone3 Q=n222
Xclk_r_REG168_S1 DFFQX1TR $PINS D=n170 CK=clk_clone2 Q=n276
Xclk_r_REG194_S1 DFFQX1TR $PINS D=n162 CK=clk_clone1 Q=n268
Xclk_r_REG205_S1 DFFQX1TR $PINS D=n153 CK=clk_clone2 Q=n259
Xclk_r_REG216_S1 DFFQX1TR $PINS D=n144 CK=clk_clone1 Q=n250
Xclk_r_REG227_S1 DFFQX1TR $PINS D=n135 CK=clk_clone3 Q=n241
Xclk_r_REG238_S1 DFFQX1TR $PINS D=n126 CK=clk_clone1 Q=n232
Xclk_r_REG249_S1 DFFQX1TR $PINS D=n117 CK=clk_clone3 Q=n223
Xclk_r_REG163_S1 DFFQX1TR $PINS D=n292 CK=clk_clone2 Q=n186
Xclk_r_REG165_S1 DFFQX1TR $PINS D=n286 CK=clk_clone2 Q=n180
Xclk_r_REG160_S1 DFFQX1TR $PINS D=n301 CK=clk_clone2 Q=n195
Xclk_r_REG158_S1 DFFQX1TR $PINS D=n308 CK=clk_clone2 Q=n201
Xclk_r_REG159_S1 DFFQX1TR $PINS D=n304 CK=clk_clone2 Q=n198
Xclk_r_REG164_S1 DFFQX1TR $PINS D=n289 CK=clk_clone2 Q=n183
Xclk_r_REG170_S1 DFFQX1TR $PINS D=n172 CK=clk Q=n278
Xclk_r_REG196_S1 DFFQX1TR $PINS D=n164 CK=clk Q=n270
Xclk_r_REG195_S1 DFFQX1TR $PINS D=n163 CK=clk Q=n269
Xclk_r_REG193_S1 DFFQX1TR $PINS D=n161 CK=clk_clone1 Q=n267
Xclk_r_REG207_S1 DFFQX1TR $PINS D=n155 CK=clk Q=n261
Xclk_r_REG204_S1 DFFQX1TR $PINS D=n152 CK=clk_clone2 Q=n258
Xclk_r_REG218_S1 DFFQX1TR $PINS D=n146 CK=clk Q=n252
Xclk_r_REG217_S1 DFFQX1TR $PINS D=n145 CK=clk Q=n251
Xclk_r_REG215_S1 DFFQX1TR $PINS D=n143 CK=clk_clone1 Q=n249
Xclk_r_REG229_S1 DFFQX1TR $PINS D=n137 CK=clk Q=n243
Xclk_r_REG228_S1 DFFQX1TR $PINS D=n136 CK=clk Q=n242
Xclk_r_REG226_S1 DFFQX1TR $PINS D=n134 CK=clk_clone2 Q=n240
Xclk_r_REG240_S1 DFFQX1TR $PINS D=n128 CK=clk Q=n234
Xclk_r_REG239_S1 DFFQX1TR $PINS D=n127 CK=clk_clone2 Q=n233
Xclk_r_REG237_S1 DFFQX1TR $PINS D=n125 CK=clk_clone1 Q=n231
Xclk_r_REG251_S1 DFFQX1TR $PINS D=n119 CK=clk Q=n225
Xclk_r_REG250_S1 DFFQX1TR $PINS D=n118 CK=clk Q=n224
Xclk_r_REG167_S1 DFFQX1TR $PINS D=n306 CK=clk_clone2 Q=n203
Xclk_r_REG201_S1 DFFQX1TR $PINS D=n169 CK=clk Q=n275
Xclk_r_REG212_S1 DFFQX1TR $PINS D=n160 CK=clk_clone2 Q=n266
Xclk_r_REG223_S1 DFFQX1TR $PINS D=n151 CK=clk_clone2 Q=n257
Xclk_r_REG234_S1 DFFQX1TR $PINS D=n142 CK=clk_clone2 Q=n248
Xclk_r_REG245_S1 DFFQX1TR $PINS D=n133 CK=clk_clone2 Q=n239
Xclk_r_REG256_S1 DFFQX1TR $PINS D=n124 CK=clk Q=n230
Xclk_r_REG179_S1 DFFQX1TR $PINS D=n115 CK=clk_clone2 Q=n221
XU3 AO22X1TR $PINS A0=n31 A1=n40 B0=n50 B1=n210 Y=n104
XU4 AO22X1TR $PINS A0=n25 A1=n41 B0=n56 B1=n217 Y=n111
XU5 AO22X1TR $PINS A0=n25 A1=n45 B0=n56 B1=n253 Y=n147
XU6 AO22X1TR $PINS A0=n25 A1=n42 B0=n56 B1=n226 Y=n120
XU7 AO22X1TR $PINS A0=n31 A1=n42 B0=n50 B1=n228 Y=n122
XU8 AO22X1TR $PINS A0=n25 A1=n43 B0=n56 B1=n235 Y=n129
XU9 AO22X1TR $PINS A0=n31 A1=n43 B0=n50 B1=n237 Y=n131
XU10 AO22X1TR $PINS A0=n25 A1=n44 B0=n56 B1=n244 Y=n138
XU11 AO22X1TR $PINS A0=n31 A1=n44 B0=n50 B1=n246 Y=n140
XU12 AO22X1TR $PINS A0=n25 A1=n46 B0=n56 B1=n262 Y=n156
XU13 AO22X1TR $PINS A0=n31 A1=n46 B0=n50 B1=n264 Y=n158
XU14 AO22X1TR $PINS A0=n25 A1=n47 B0=n56 B1=n271 Y=n165
XU15 AO22X1TR $PINS A0=n31 A1=n47 B0=n50 B1=n273 Y=n167
XU16 AO22X1TR $PINS A0=n31 A1=FE_OFN22_FE_DBTN11_reset B0=n50 B1=n277 Y=n171
XU21 AOI22X1TR $PINS A0=FE_OFN28_FE_DBTN3_n3 A1=n281 B0=FE_DBTN4_n1 B1=n282
+ Y=n65
XU22 INVX2TR $PINS A=FE_OFN17_pe_in_pk_wrb_addr__1 Y=n26
XU24 CLKINVX2TR $PINS A=n203 Y=n17
XU25 OAI2BB1X1TR $PINS A0N=n187 A1N=n185 B0=n17 Y=n18
XU26 AND3X2TR $PINS A=n13 B=n12 C=n11 Y=n10
XU27 AO22X1TR $PINS A0=n25 A1=n40 B0=n56 B1=n208 Y=n102
XU28 AO22X1TR $PINS A0=n31 A1=n41 B0=n50 B1=n219 Y=n113
XU29 AO22X1TR $PINS A0=n31 A1=n45 B0=n50 B1=n255 Y=n149
XU30 AO22X1TR $PINS A0=n25 A1=FE_OFN22_FE_DBTN11_reset B0=n56 B1=n282 Y=n176
XU31 OR2X2TR $PINS A=rdb_addr<0> B=n62 Y=n1
XU32 INVX2TR $PINS A=n28 Y=n57
XU33 AND3X2TR $PINS A=n65 B=n16 C=n15 Y=n14
XU35 NOR3X2TR $PINS A=n4 B=n14 C=n10 Y=n70
XU38 NAND2X1TR $PINS A=n18 B=n186 Y=data_out<2>
XU41 INVX2TR $PINS A=wrb_addr<3> Y=n37
XU42 NAND2X1TR $PINS A=FE_OFN27_FE_DBTN4_n1 B=n284 Y=n11
XU43 INVX2TR $PINS A=n25 Y=n56
XU44 INVX2TR $PINS A=n31 Y=n50
XU45 OR2X2TR $PINS A=rdb_addr<1> B=n64 Y=n3
XU48 NOR2BX1TR $PINS AN=wrb_data<2> B=FE_OFN14_reset Y=n42
XU49 NOR2BX1TR $PINS AN=wrb_data<3> B=reset Y=n43
XU50 NOR2BX1TR $PINS AN=wrb_data<4> B=reset Y=n44
XU51 NOR2BX2TR $PINS AN=wrb_data<5> B=reset Y=n45
XU52 NOR2BX1TR $PINS AN=wrb_data<6> B=reset Y=n46
XU53 NOR2BX1TR $PINS AN=wrb_data<7> B=reset Y=n47
XU54 OR2X2TR $PINS A=FE_OFN14_reset B=rdb_addr<3> Y=n4
XU56 AOI21X1TR $PINS A0=n63 A1=n276 B0=n69 Y=n13
XU57 NAND2X1TR $PINS A=n63 B=n280 Y=n15
XU58 NOR2X2TR $PINS A=n64 B=n62 Y=n63
XU60 NAND4X1TR $PINS A=n61 B=n278 C=rdb_addr<3> D=FE_DBTN11_reset Y=n68
XU61 AOI22X1TR $PINS A0=FE_DBTN3_n3 A1=n279 B0=n61 B1=n283 Y=n12
XU62 AOI21X1TR $PINS A0=n61 A1=n277 B0=rdb_addr<2> Y=n16
XU64 INVX2TR $PINS A=FE_OFN51_pe_in_pk_wrb_addr__2 Y=n24
XU65 AOI32X4TR $PINS A0=n179 A1=n180 A2=n181 B0=n203 B1=n180 Y=data_out<0>
XU66 AOI32X1TR $PINS A0=n200 A1=n201 A2=n202 B0=n203 B1=n201 Y=data_out<7>
XU67 AOI32X1TR $PINS A0=n194 A1=n195 A2=n196 B0=n203 B1=n195 Y=data_out<5>
XU68 AOI32X1TR $PINS A0=n197 A1=n198 A2=n199 B0=n203 B1=n198 Y=data_out<6>
XU69 AOI32X1TR $PINS A0=n182 A1=n183 A2=n184 B0=n203 B1=n183 Y=data_out<1>
XU70 AOI32X1TR $PINS A0=n188 A1=n189 A2=n190 B0=n203 B1=n189 Y=data_out<3>
XU71 AOI32X1TR $PINS A0=n191 A1=n192 A2=n193 B0=n203 B1=n192 Y=data_out<4>
XU73 NAND3X1TR $PINS A=wrb B=wrb_addr<0> C=n37 Y=n22
XU74 OAI31X4TR $PINS A0=FE_OFN17_pe_in_pk_wrb_addr__1 A1=n24 A2=n22
+ B0=FE_OFN22_FE_DBTN11_reset Y=n19
XU75 NOR2BX1TR $PINS AN=wrb_data<0> B=reset Y=n40
XU76 INVX2TR $PINS A=n19 Y=n53
XU77 AO22X1TR $PINS A0=n19 A1=n40 B0=n53 B1=n204 Y=n98
XU79 NAND2X1TR $PINS A=FE_OFN17_pe_in_pk_wrb_addr__1
+ B=FE_OFN51_pe_in_pk_wrb_addr__2 Y=n35
XU80 OAI21XLTR $PINS A0=n35 A1=n22 B0=FE_OFN49_reset Y=n20
XU82 AO22X1TR $PINS A0=n48 A1=n40 B0=FE_OFN42_n20 B1=n205 Y=n99
XU83 OAI31X4TR $PINS A0=FE_OFN51_pe_in_pk_wrb_addr__2 A1=n26 A2=n22
+ B0=FE_OFN22_FE_DBTN11_reset Y=n21
XU84 INVX2TR $PINS A=n21 Y=n54
XU85 AO22X1TR $PINS A0=n21 A1=n40 B0=n54 B1=n206 Y=n100
XU86 OAI31X4TR $PINS A0=FE_OFN17_pe_in_pk_wrb_addr__1 A1=n22
+ A2=FE_OFN51_pe_in_pk_wrb_addr__2 B0=FE_OFN22_FE_DBTN11_reset Y=n23
XU87 INVX2TR $PINS A=n23 Y=n55
XU88 AO22X1TR $PINS A0=n23 A1=n40 B0=n55 B1=n207 Y=n101
XU89 NAND2BX1TR $PINS AN=wrb_addr<0> B=n24 Y=n30
XU91 OAI31X4TR $PINS A0=n26 A1=n30 A2=n29 B0=FE_OFN22_FE_DBTN11_reset Y=n25
XU92 NAND2X1TR $PINS A=FE_OFN51_pe_in_pk_wrb_addr__2 B=n26 Y=n27
XU93 OAI31X4TR $PINS A0=wrb_addr<0> A1=n29 A2=n27 B0=FE_OFN22_FE_DBTN11_reset
+ Y=n28
XU94 AO22X1TR $PINS A0=n28 A1=n40 B0=n57 B1=n209 Y=n103
XU95 OAI31X4TR $PINS A0=FE_OFN17_pe_in_pk_wrb_addr__1 A1=n30 A2=n29
+ B0=FE_OFN22_FE_DBTN11_reset Y=n31
XU96 NOR3X1TR $PINS A=FE_OFN17_pe_in_pk_wrb_addr__1
+ B=FE_OFN51_pe_in_pk_wrb_addr__2 C=wrb_addr<0> Y=n34
XU97 OAI21X1TR $PINS A0=n34 A1=n37 B0=wrb Y=n38
XU98 OAI31X4TR $PINS A0=wrb_addr<0> A1=n38 A2=n35 B0=FE_OFN49_reset Y=n36
XU99 AO22X1TR $PINS A0=n36 A1=n40 B0=n58 B1=n211 Y=n105
XU100 OAI21X4TR $PINS A0=n38 A1=n37 B0=FE_OFN49_reset Y=n39
XU102 INVX2TR $PINS A=n39 Y=n51
XU103 AO22X1TR $PINS A0=n39 A1=n40 B0=n51 B1=n212 Y=n106
XU104 NOR2BX1TR $PINS AN=wrb_data<1> B=reset Y=n41
XU105 AO22X1TR $PINS A0=n19 A1=n41 B0=n53 B1=n213 Y=n107
XU106 AO22X1TR $PINS A0=n48 A1=n41 B0=FE_OFN42_n20 B1=n214 Y=n108
XU107 AO22X1TR $PINS A0=n21 A1=n41 B0=n54 B1=n215 Y=n109
XU108 AO22X1TR $PINS A0=n23 A1=n41 B0=n55 B1=n216 Y=n110
XU109 AO22X1TR $PINS A0=n28 A1=n41 B0=n57 B1=n218 Y=n112
XU110 AO22X1TR $PINS A0=n36 A1=n41 B0=n58 B1=n220 Y=n114
XU111 AO22X1TR $PINS A0=n39 A1=n41 B0=n51 B1=n221 Y=n115
XU112 AO22X1TR $PINS A0=n19 A1=n42 B0=n53 B1=n222 Y=n116
XU113 AO22X1TR $PINS A0=n48 A1=n42 B0=FE_OFN42_n20 B1=n223 Y=n117
XU114 AO22X1TR $PINS A0=n21 A1=n42 B0=n54 B1=n224 Y=n118
XU115 AO22X1TR $PINS A0=n23 A1=n42 B0=n55 B1=n225 Y=n119
XU116 AO22X1TR $PINS A0=n28 A1=n42 B0=n57 B1=n227 Y=n121
XU117 AO22X1TR $PINS A0=n36 A1=n42 B0=n58 B1=n229 Y=n123
XU118 AO22X1TR $PINS A0=n39 A1=n42 B0=n51 B1=n230 Y=n124
XU119 AO22X1TR $PINS A0=n19 A1=n43 B0=n53 B1=n231 Y=n125
XU120 AO22X1TR $PINS A0=n48 A1=n43 B0=FE_OFN42_n20 B1=n232 Y=n126
XU121 AO22X1TR $PINS A0=n21 A1=n43 B0=n54 B1=n233 Y=n127
XU122 AO22X1TR $PINS A0=n23 A1=n43 B0=n55 B1=n234 Y=n128
XU123 AO22X1TR $PINS A0=n28 A1=n43 B0=n57 B1=n236 Y=n130
XU124 AO22X1TR $PINS A0=n36 A1=n43 B0=n58 B1=n238 Y=n132
XU125 AO22X1TR $PINS A0=n39 A1=n43 B0=n51 B1=n239 Y=n133
XU126 AO22X1TR $PINS A0=n19 A1=n44 B0=n53 B1=n240 Y=n134
XU127 AO22X1TR $PINS A0=n48 A1=n44 B0=FE_OFN42_n20 B1=n241 Y=n135
XU128 AO22X1TR $PINS A0=n21 A1=n44 B0=n54 B1=n242 Y=n136
XU129 AO22X1TR $PINS A0=n23 A1=n44 B0=n55 B1=n243 Y=n137
XU130 AO22X1TR $PINS A0=n28 A1=n44 B0=n57 B1=n245 Y=n139
XU131 AO22X1TR $PINS A0=n36 A1=n44 B0=n58 B1=n247 Y=n141
XU132 AO22X1TR $PINS A0=n39 A1=n44 B0=n51 B1=n248 Y=n142
XU133 AO22X1TR $PINS A0=n19 A1=n45 B0=n53 B1=n249 Y=n143
XU134 AO22X1TR $PINS A0=n48 A1=n45 B0=FE_OFN42_n20 B1=n250 Y=n144
XU135 AO22X1TR $PINS A0=n21 A1=n45 B0=n54 B1=n251 Y=n145
XU136 AO22X1TR $PINS A0=n23 A1=n45 B0=n55 B1=n252 Y=n146
XU137 AO22X1TR $PINS A0=n28 A1=n45 B0=n57 B1=n254 Y=n148
XU138 AO22X1TR $PINS A0=n36 A1=n45 B0=n58 B1=n256 Y=n150
XU139 AO22X1TR $PINS A0=n39 A1=n45 B0=n51 B1=n257 Y=n151
XU140 AO22X1TR $PINS A0=n19 A1=n46 B0=n53 B1=n258 Y=n152
XU141 AO22X1TR $PINS A0=n48 A1=n46 B0=FE_OFN42_n20 B1=n259 Y=n153
XU142 AO22X1TR $PINS A0=n21 A1=n46 B0=n54 B1=n260 Y=n154
XU143 AO22X1TR $PINS A0=n23 A1=n46 B0=n55 B1=n261 Y=n155
XU144 AO22X1TR $PINS A0=n28 A1=n46 B0=n57 B1=n263 Y=n157
XU145 AO22X1TR $PINS A0=n36 A1=n46 B0=n58 B1=n265 Y=n159
XU146 AO22X1TR $PINS A0=n39 A1=n46 B0=n51 B1=n266 Y=n160
XU147 AO22X1TR $PINS A0=n19 A1=n47 B0=n53 B1=n267 Y=n161
XU148 AO22X1TR $PINS A0=n48 A1=n47 B0=FE_OFN42_n20 B1=n268 Y=n162
XU149 AO22X1TR $PINS A0=n21 A1=n47 B0=n54 B1=n269 Y=n163
XU150 AO22X1TR $PINS A0=n23 A1=n47 B0=n55 B1=n270 Y=n164
XU151 AO22X1TR $PINS A0=n28 A1=n47 B0=n57 B1=n272 Y=n166
XU152 AO22X1TR $PINS A0=n36 A1=n47 B0=n58 B1=n274 Y=n168
XU153 AO22X1TR $PINS A0=n39 A1=n47 B0=n51 B1=n275 Y=n169
XU154 AO22X1TR $PINS A0=n48 A1=FE_OFN49_reset B0=FE_OFN42_n20 B1=n276 Y=n170
XU155 AO22X1TR $PINS A0=n39 A1=FE_OFN22_FE_DBTN11_reset B0=n51 B1=n278 Y=n172
XU156 AO22X1TR $PINS A0=n19 A1=FE_OFN49_reset B0=n53 B1=n279 Y=n173
XU157 AO22X1TR $PINS A0=n21 A1=FE_OFN22_FE_DBTN11_reset B0=n54 B1=n280 Y=n174
XU158 AO22X1TR $PINS A0=n23 A1=FE_OFN22_FE_DBTN11_reset B0=n55 B1=n281 Y=n175
XU159 AO22X1TR $PINS A0=n28 A1=FE_OFN49_reset B0=n57 B1=n283 Y=n177
XU160 AO22X1TR $PINS A0=n36 A1=FE_OFN49_reset B0=n58 B1=n284 Y=n178
XU162 NOR2X2TR $PINS A=rdb_addr<0> B=rdb_addr<1> Y=n61
XU163 NAND2X1TR $PINS A=rdb_addr<2> B=n70 Y=n306
XU164 AOI22X1TR $PINS A0=n63 A1=n205 B0=FE_DBTN3_n3 B1=n204 Y=n287
XU165 NOR2X1TR $PINS A=rdb_addr<2> B=n68 Y=n96
XU166 AND2X4TR $PINS A=n70 B=n69 Y=n95
XU167 AOI22X1TR $PINS A0=n63 A1=n206 B0=FE_OFN28_FE_DBTN3_n3 B1=n207 Y=n72
XU168 AOI22X1TR $PINS A0=n61 A1=n210 B0=FE_DBTN4_n1 B1=n208 Y=n71
XU169 NAND2X1TR $PINS A=n72 B=n71 Y=n73
XU170 AOI22X1TR $PINS A0=n96 A1=n212 B0=n95 B1=n73 Y=n286
XU171 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n209 B0=FE_OFN27_FE_DBTN4_n1 B1=n211
+ Y=n285
XU172 AOI22X1TR $PINS A0=n63 A1=n214 B0=FE_DBTN3_n3 B1=n213 Y=n290
XU173 AOI22X1TR $PINS A0=n63 A1=n215 B0=FE_OFN28_FE_DBTN3_n3 B1=n216 Y=n75
XU174 AOI22X1TR $PINS A0=n61 A1=n219 B0=FE_DBTN4_n1 B1=n217 Y=n74
XU175 NAND2X1TR $PINS A=n75 B=n74 Y=n76
XU176 AOI22X1TR $PINS A0=n96 A1=n221 B0=n95 B1=n76 Y=n289
XU177 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n218 B0=FE_OFN27_FE_DBTN4_n1 B1=n220
+ Y=n288
XU178 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n223 B0=FE_DBTN3_n3 B1=n222 Y=n293
XU179 AOI22X1TR $PINS A0=n63 A1=n224 B0=FE_OFN28_FE_DBTN3_n3 B1=n225 Y=n78
XU180 AOI22X1TR $PINS A0=n61 A1=n228 B0=FE_DBTN4_n1 B1=n226 Y=n77
XU181 NAND2X1TR $PINS A=n78 B=n77 Y=n79
XU182 AOI22X1TR $PINS A0=n96 A1=n230 B0=n95 B1=n79 Y=n292
XU183 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n227 B0=FE_OFN27_FE_DBTN4_n1 B1=n229
+ Y=n291
XU184 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n232 B0=FE_DBTN3_n3 B1=n231 Y=n296
XU185 AOI22X1TR $PINS A0=n63 A1=n233 B0=FE_OFN28_FE_DBTN3_n3 B1=n234 Y=n81
XU186 AOI22X1TR $PINS A0=n61 A1=n237 B0=FE_DBTN4_n1 B1=n235 Y=n80
XU187 NAND2X1TR $PINS A=n81 B=n80 Y=n82
XU188 AOI22X1TR $PINS A0=n96 A1=n239 B0=n95 B1=n82 Y=n295
XU189 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n236 B0=FE_OFN27_FE_DBTN4_n1 B1=n238
+ Y=n294
XU190 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n241 B0=FE_DBTN3_n3 B1=n240 Y=n299
XU191 AOI22X1TR $PINS A0=n63 A1=n242 B0=FE_OFN28_FE_DBTN3_n3 B1=n243 Y=n84
XU192 AOI22X1TR $PINS A0=n61 A1=n246 B0=FE_DBTN4_n1 B1=n244 Y=n83
XU193 NAND2X1TR $PINS A=n84 B=n83 Y=n85
XU194 AOI22X1TR $PINS A0=n96 A1=n248 B0=n95 B1=n85 Y=n298
XU195 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n245 B0=FE_OFN27_FE_DBTN4_n1 B1=n247
+ Y=n297
XU196 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n250 B0=FE_DBTN3_n3 B1=n249 Y=n302
XU197 AOI22X1TR $PINS A0=n63 A1=n251 B0=FE_OFN28_FE_DBTN3_n3 B1=n252 Y=n87
XU198 AOI22X1TR $PINS A0=n61 A1=n255 B0=FE_DBTN4_n1 B1=n253 Y=n86
XU199 NAND2X1TR $PINS A=n87 B=n86 Y=n88
XU200 AOI22X1TR $PINS A0=n96 A1=n257 B0=n95 B1=n88 Y=n301
XU201 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n254 B0=FE_OFN27_FE_DBTN4_n1 B1=n256
+ Y=n300
XU202 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n259 B0=FE_DBTN3_n3 B1=n258 Y=n305
XU203 AOI22X1TR $PINS A0=n63 A1=n260 B0=FE_OFN28_FE_DBTN3_n3 B1=n261 Y=n90
XU204 AOI22X1TR $PINS A0=n61 A1=n264 B0=FE_DBTN4_n1 B1=n262 Y=n89
XU205 NAND2X1TR $PINS A=n90 B=n89 Y=n91
XU206 AOI22X1TR $PINS A0=n96 A1=n266 B0=n95 B1=n91 Y=n304
XU207 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n263 B0=FE_OFN27_FE_DBTN4_n1 B1=n265
+ Y=n303
XU208 AOI22X1TR $PINS A0=FE_OFN37_n63 A1=n268 B0=FE_DBTN3_n3 B1=n267 Y=n309
XU209 AOI22X1TR $PINS A0=n63 A1=n269 B0=FE_OFN28_FE_DBTN3_n3 B1=n270 Y=n93
XU210 AOI22X1TR $PINS A0=n61 A1=n273 B0=FE_DBTN4_n1 B1=n271 Y=n92
XU211 NAND2X1TR $PINS A=n93 B=n92 Y=n94
XU212 AOI22X1TR $PINS A0=n96 A1=n275 B0=n95 B1=n94 Y=n308
XU213 AOI22X1TR $PINS A0=FE_OFN36_n61 A1=n272 B0=FE_OFN27_FE_DBTN4_n1 B1=n274
+ Y=n307
XU90 NAND2X1TR $PINS A=wrb B=n37 Y=n29
XU18 INVX2TR $PINS A=n36 Y=n58
.ENDS

.SUBCKT MULT_single_1 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> B<7> B<6>
+ B<5> B<4> B<3> B<2> B<1> B<0> data_out<7> data_out<6> data_out<5> data_out<4>
+ data_out<3> data_out<2> data_out<1> data_out<0> clk_clone3 clk_clone2
+ clk_clone1 clk
XPLACEDFE_OFC18_n4 CLKBUFX2TR $PINS A=A<3> Y=FE_OFN18_n4
Xclk_r_REG166_S2 DFFQX1TR $PINS D=B<0> CK=clk Q=n244
Xclk_r_REG131_S2 DFFQX1TR $PINS D=n255 CK=clk Q=n243
Xclk_r_REG117_S3 DFFQX1TR $PINS D=n191 CK=clk_clone3 Q=n242
Xclk_r_REG134_S2 DFFQX1TR $PINS D=n155 CK=clk_clone3 Q=n240
Xclk_r_REG144_S2 DFFQX1TR $PINS D=n156 CK=clk_clone3 Q=n239
Xclk_r_REG106_S3 DFFQX1TR $PINS D=n253 CK=clk_clone3 Q=n237
Xclk_r_REG115_S3 DFFQX1TR $PINS D=n158 CK=clk_clone3 Q=n235
Xclk_r_REG112_S3 DFFQX1TR $PINS D=n80 CK=clk_clone3 Q=n233
Xclk_r_REG86_S3 DFFQX1TR $PINS D=n247 CK=clk_clone3 Q=n226
Xclk_r_REG85_S2 DFFQX1TR $PINS D=n181 CK=clk Q=n224
Xclk_r_REG99_S2 DFFQX1TR $PINS D=n180 CK=clk Q=n223
Xclk_r_REG104_S2 DFFQX1TR $PINS D=n182 CK=clk Q=n222
Xclk_r_REG109_S2 DFFQX1TR $PINS D=n179 CK=clk_clone1 Q=n221
Xclk_r_REG116_S2 DFFQX1TR $PINS D=n254 CK=clk_clone1 Q=n219
Xclk_r_REG129_S2 DFFQX1TR $PINS D=n161 CK=clk_clone2 Q=n218
Xclk_r_REG113_S3 DFFQX1TR $PINS D=n79 CK=clk_clone3 Q=n216
Xclk_r_REG121_S2 DFFQX1TR $PINS D=n176 CK=clk_clone3 Q=n214
Xclk_r_REG118_S2 DFFQX1TR $PINS D=n154 CK=clk_clone1 Q=n212
Xclk_r_REG122_S2 DFFQX1TR $PINS D=n177 CK=clk_clone3 Q=n211
Xclk_r_REG147_S2 DFFQX1TR $PINS D=n167 CK=clk_clone2 Q=n204
Xclk_r_REG140_S2 DFFQX1TR $PINS D=n145 CK=clk_clone3 Q=n203
Xclk_r_REG125_S2 DFFQX1TR $PINS D=n174 CK=clk_clone3 Q=n200
Xclk_r_REG126_S2 DFFQX1TR $PINS D=n175 CK=clk_clone3 Q=n199
Xclk_r_REG127_S2 DFFQX1TR $PINS D=n173 CK=clk_clone3 Q=n198
Xclk_r_REG149_S2 DFFQX1TR $PINS D=n184 CK=clk_clone3 Q=n196
Xclk_r_REG136_S2 DFFQX1TR $PINS D=n169 CK=clk_clone3 Q=n195
Xclk_r_REG130_S2 DFFQX1TR $PINS D=n170 CK=clk_clone3 Q=n193
Xclk_r_REG105_S3 DFFQX1TR $PINS D=n252 CK=clk_clone3 Q=n238
Xclk_r_REG102_S3 DFFQX1TR $PINS D=n147 CK=clk_clone3 Q=n232
Xclk_r_REG110_S2 DFFQX1TR $PINS D=n178 CK=clk_clone3 Q=n220
Xclk_r_REG123_S3 DFFQX1TR $PINS D=n250 CK=clk_clone3 Q=n236
Xclk_r_REG114_S3 DFFQX1TR $PINS D=n164 CK=clk_clone3 Q=n234
Xclk_r_REG100_S3 DFFQX1TR $PINS D=n248 CK=clk_clone3 Q=n230
Xclk_r_REG101_S3 DFFQX1TR $PINS D=n249 CK=clk_clone3 Q=n229
Xclk_r_REG107_S3 DFFQX1TR $PINS D=n251 CK=clk_clone3 Q=n225
Xclk_r_REG138_S2 DFFQX1TR $PINS D=n186 CK=clk_clone3 Q=n209
Xclk_r_REG119_S2 DFFQX1TR $PINS D=n162 CK=clk_clone3 Q=n206
Xclk_r_REG146_S2 DFFQX1TR $PINS D=n168 CK=clk_clone3 Q=n205
Xclk_r_REG148_S2 DFFQX1TR $PINS D=n166 CK=clk_clone3 Q=n194
Xclk_r_REG141_S2 DFFQX1TR $PINS D=n188 CK=clk_clone3 Q=n202
Xclk_r_REG137_S2 DFFQX1TR $PINS D=n187 CK=clk_clone3 Q=n210
Xclk_r_REG139_S2 DFFQX1TR $PINS D=n185 CK=clk_clone3 Q=n208
Xclk_r_REG135_S2 DFFQX1TR $PINS D=n146 CK=clk_clone3 Q=n213
Xclk_r_REG145_S2 DFFQX1TR $PINS D=n183 CK=clk_clone3 Q=n207
Xclk_r_REG108_S3 DFFQX1TR $PINS D=n246 CK=clk_clone3 Q=n215
Xclk_r_REG260_S2 DFFQX1TR $PINS D=n245 CK=clk_clone3 Q=n241
Xclk_r_REG97_S3 DFFQX1TR $PINS D=n150 CK=clk_clone3 Q=n228
Xclk_r_REG259_S1 DFFQX1TR $PINS D=reset CK=clk_clone3 Q=n245
Xclk_r_REG124_S2 DFFQX1TR $PINS D=n171 CK=clk_clone2 Q=n201
Xclk_r_REG128_S2 DFFQX1TR $PINS D=n172 CK=clk_clone3 Q=n197
Xclk_r_REG103_S3 DFFQX1TR $PINS D=n148 CK=clk_clone3 Q=n231
Xclk_r_REG111_S3 DFFQX1TR $PINS D=n165 CK=clk_clone3 Q=n217
XU1 XOR2X1TR $PINS A=n73 B=n72 Y=n75
XU2 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n132 B0=B<6> B1=n136 Y=n114
XU3 INVX2TR $PINS A=B<0> Y=n159
XU4 INVX2TR $PINS A=B<4> Y=n140
XU5 AOI21X1TR $PINS A0=n205 A1=n202 B0=n94 Y=n72
XU6 INVX2TR $PINS A=B<1> Y=n137
XU7 INVX2TR $PINS A=A<7> Y=n118
XU9 INVX2TR $PINS A=A<5> Y=n131
XU10 XOR2X1TR $PINS A=n47 B=n46 Y=n48
XU11 OAI21X1TR $PINS A0=n228 A1=n59 B0=n227 Y=n46
XU12 CLKINVX2TR $PINS A=n123 Y=n141
XU15 INVX1TR $PINS A=n12 Y=n255
XU16 INVX1TR $PINS A=n108 Y=n15
XU17 INVX1TR $PINS A=n250 Y=n57
XU18 INVX1TR $PINS A=B<6> Y=n132
XU19 OA21XLTR $PINS A0=n32 A1=n212 B0=n31 Y=n191
XU22 AND2X2TR $PINS A=n1 B=n2 Y=data_out<4>
XU23 XNOR2X1TR $PINS A=n86 B=n54 Y=n2
XU24 XOR2X1TR $PINS A=n204 B=n218 Y=n97
XU25 AO21X1TR $PINS A0=n12 A1=n190 B0=n113 Y=n161
XU26 OAI22X1TR $PINS A0=n126 A1=n124 B0=n117 B1=n127 Y=n167
XU27 NOR4BX1TR $PINS AN=n56 B=n55 C=n241 D=n245 Y=data_out<0>
XU28 XNOR2X1TR $PINS A=n101 B=n100 Y=n158
XU29 OAI21X1TR $PINS A0=n83 A1=n231 B0=n82 Y=n6
XU31 XOR2X1TR $PINS A=n64 B=n11 Y=n16
XU32 NOR2X2TR $PINS A=n105 B=n61 Y=data_out<2>
XU33 NOR2X1TR $PINS A=n48 B=n105 Y=data_out<3>
XU34 XOR2X1TR $PINS A=n104 B=n87 Y=n88
XU35 AOI21X1TR $PINS A0=n86 A1=n7 B0=n6 Y=n104
XU36 XNOR2X1TR $PINS A=n60 B=n59 Y=n61
XU37 NAND2X1TR $PINS A=n36 B=A<1> Y=n123
XU38 AOI31X1TR $PINS A0=A<6> A1=A<5> A2=n118 B0=n108 Y=n126
XU39 XOR2X1TR $PINS A=n5 B=n235 Y=n106
XU40 OAI21X1TR $PINS A0=n104 A1=n103 B0=n102 Y=n5
XU41 NOR2X1TR $PINS A=n106 B=n105 Y=data_out<7>
XU42 AND2X2TR $PINS A=n223 B=n195 Y=n64
XU43 CLKINVX2TR $PINS A=n45 Y=n59
XU44 NAND2X1TR $PINS A=A<2> B=A<1> Y=n13
XU45 AND2X2TR $PINS A=n84 B=n85 Y=n7
XU46 OR2X1TR $PINS A=A<2> B=A<1> Y=n107
XU47 XOR2X1TR $PINS A=n26 B=n25 Y=n34
XU48 XOR2X1TR $PINS A=n81 B=n69 Y=n70
XU49 CLKINVX2TR $PINS A=n209 Y=n98
XU50 OAI22X1TR $PINS A0=n153 A1=n115 B0=n130 B1=n157 Y=n188
XU51 AND2X1TR $PINS A=n222 B=n35 Y=n252
XU52 INVX1TR $PINS A=n43 Y=n44
XU53 OAI21X1TR $PINS A0=B<6> A1=n144 B0=n18 Y=n179
XU54 OAI21X1TR $PINS A0=B<3> A1=n144 B0=n21 Y=n182
XU55 OAI21X1TR $PINS A0=B<4> A1=n144 B0=n19 Y=n181
XU56 NOR2X1TR $PINS A=n17 B=n16 Y=n249
XU57 NAND2X1TR $PINS A=n17 B=n16 Y=n248
XU58 AO21X2TR $PINS A0=n45 A1=n39 B0=n38 Y=n86
XU59 OAI21X1TR $PINS A0=n91 A1=n90 B0=n89 Y=n92
XU60 NOR2X1TR $PINS A=n234 B=n217 Y=n103
XU61 OAI21X1TR $PINS A0=n199 A1=n208 B0=n26 Y=n9
XU62 INVX1TR $PINS A=B<7> Y=n121
XU63 AO21X1TR $PINS A0=n74 A1=n73 B0=n24 Y=n165
XU64 OAI21X1TR $PINS A0=B<2> A1=n144 B0=n20 Y=n254
XU65 NOR3X1TR $PINS A=FE_OFN18_n4 B=A<4> C=n131 Y=n43
XU66 AOI31X1TR $PINS A0=FE_OFN18_n4 A1=A<4> A2=n131 B0=n43 Y=n153
XU67 CLKINVX2TR $PINS A=B<3> Y=n116
XU68 AOI22X1TR $PINS A0=A<5> A1=n116 B0=B<3> B1=n131 Y=n115
XU69 AOI22X1TR $PINS A0=A<5> A1=n140 B0=B<4> B1=n131 Y=n130
XU70 NAND2X1TR $PINS A=FE_OFN18_n4 B=A<4> Y=n8
XU71 OAI21X1TR $PINS A0=FE_OFN18_n4 A1=A<4> B0=n8 Y=n157
XU72 AOI2BB1X1TR $PINS A0N=n223 A1N=n195 B0=n64 Y=n26
XU73 OAI2BB1X1TR $PINS A0N=n208 A1N=n199 B0=n9 Y=n17
XU74 XOR2X1TR $PINS A=n213 B=n239 Y=n10
XU75 XOR2X1TR $PINS A=n10 B=n200 Y=n62
XU76 XOR2X1TR $PINS A=n221 B=n62 Y=n11
XU77 OAI21X1TR $PINS A0=A<2> A1=A<1> B0=n13 Y=n12
XU79 INVX2TR $PINS A=FE_OFN18_n4 Y=n136
XU80 AO22X1TR $PINS A0=FE_OFN18_n4 A1=n107 B0=n13 B1=n136 Y=n190
XU81 OAI22X1TR $PINS A0=n136 A1=n121 B0=B<7> B1=FE_OFN18_n4 Y=n113
XU82 NAND2X1TR $PINS A=A<5> B=A<6> Y=n14
XU83 OAI21X1TR $PINS A0=A<5> A1=A<6> B0=n14 Y=n127
XU84 NOR3X1TR $PINS A=A<5> B=A<6> C=n118 Y=n108
XU85 OAI31X1TR $PINS A0=n127 A1=n118 A2=B<0> B0=n15 Y=n166
XU86 NAND2X1TR $PINS A=A<1> B=A<0> Y=n144
XU87 NOR2X1TR $PINS A=A<1> B=n36 Y=n142
XU88 CLKINVX2TR $PINS A=B<5> Y=n129
XU89 AOI22X1TR $PINS A0=n142 A1=B<6> B0=n141 B1=n129 Y=n18
XU90 AOI22X1TR $PINS A0=B<4> A1=n142 B0=n141 B1=n116 Y=n19
XU91 AOI22X1TR $PINS A0=n142 A1=B<2> B0=n141 B1=n137 Y=n20
XU92 CLKINVX2TR $PINS A=B<2> Y=n119
XU93 AOI22X1TR $PINS A0=B<3> A1=n142 B0=n141 B1=n119 Y=n21
XU94 AND2X2TR $PINS A=n220 B=n194 Y=n66
XU95 XOR2X1TR $PINS A=n197 B=n66 Y=n22
XU96 XOR2X1TR $PINS A=n22 B=n206 Y=n74
XU97 OAI21X1TR $PINS A0=n198 A1=n203 B0=n196 Y=n23
XU98 OAI2BB1X1TR $PINS A0N=n203 A1N=n198 B0=n23 Y=n73
XU99 OR2X2TR $PINS A=n202 B=n205 Y=n90
XU100 INVX1TR $PINS A=n90 Y=n94
XU101 AOI2BB1X1TR $PINS A0N=n74 A1N=n73 B0=n72 Y=n24
XU102 XOR2X1TR $PINS A=n199 B=n208 Y=n25
XU103 OAI21X1TR $PINS A0=n224 A1=n240 B0=n214 Y=n27
XU104 OAI2BB1X1TR $PINS A0N=n240 A1N=n224 B0=n27 Y=n33
XU105 NOR2X1TR $PINS A=n34 B=n33 Y=n150
XU106 AOI2BB1X1TR $PINS A0N=n193 A1N=n211 B0=n250 Y=n35
XU107 NOR2X1TR $PINS A=n222 B=n35 Y=n253
XU108 NOR2X1TR $PINS A=n207 B=n201 Y=n99
XU109 AOI21X1TR $PINS A0=n201 A1=n207 B0=n99 Y=n28
XU110 XOR2X1TR $PINS A=n28 B=n98 Y=n91
XU111 OAI21X1TR $PINS A0=n206 A1=n197 B0=n66 Y=n29
XU112 OAI2BB1X1TR $PINS A0N=n197 A1N=n206 B0=n29 Y=n89
XU113 XOR2X1TR $PINS A=n89 B=n90 Y=n30
XU114 XOR2X1TR $PINS A=n91 B=n30 Y=n164
XU115 AOI21X1TR $PINS A0=n243 A1=n244 B0=n219 Y=n32
XU116 NAND3X1TR $PINS A=n244 B=n243 C=n219 Y=n31
XU117 NOR2X1TR $PINS A=n253 B=n191 Y=n251
XU118 NAND2X1TR $PINS A=n34 B=n33 Y=n151
XU119 OAI211X1TR $PINS A0=n137 A1=n36 B0=A<1> C0=n159 Y=n154
XU120 CLKINVX2TR $PINS A=n232 Y=n85
XU121 NOR3X2TR $PINS A=n238 B=n236 C=n225 Y=n49
XU122 CLKINVX2TR $PINS A=n215 Y=n37
XU123 OAI21X1TR $PINS A0=n49 A1=n226 B0=n37 Y=n45
XU124 NOR2X1TR $PINS A=n229 B=n228 Y=n39
XU125 OAI21X1TR $PINS A0=n229 A1=n227 B0=n230 Y=n38
XU126 OAI2BB1X1TR $PINS A0N=n85 A1N=n86 B0=n231 Y=n41
XU127 NOR2X1TR $PINS A=n233 B=n216 Y=n83
XU128 CLKINVX2TR $PINS A=n83 Y=n84
XU129 NAND2X1TR $PINS A=n233 B=n216 Y=n82
XU130 NAND2X1TR $PINS A=n84 B=n82 Y=n40
XU131 XOR2X1TR $PINS A=n41 B=n40 Y=n42
XU132 OR2X2TR $PINS A=n241 B=n245 Y=n105
XU133 NOR2X4TR $PINS A=n42 B=n105 Y=data_out<5>
XU134 OAI31X1TR $PINS A0=n157 A1=n131 A2=B<0> B0=n44 Y=n169
XU135 NAND2BX1TR $PINS AN=n229 B=n230 Y=n47
XU136 NOR2X1TR $PINS A=n215 B=n49 Y=n50
XU138 OR2X2TR $PINS A=n51 B=n241 Y=n52
XU139 OR2X4TR $PINS A=n52 B=n245 Y=n53
XU140 CLKINVX6TR $PINS A=n53 Y=data_out<1>
XU141 NAND2X1TR $PINS A=n85 B=n231 Y=n54
XU142 OAI21X1TR $PINS A0=n237 A1=n238 B0=n242 Y=n56
XU143 NOR3X1TR $PINS A=n237 B=n238 C=n242 Y=n55
XU144 NOR3BX1TR $PINS AN=n222 B=n191 C=n57 Y=n246
XU145 XOR2X1TR $PINS A=n240 B=n214 Y=n58
XU146 XNOR2X1TR $PINS A=n58 B=n224 Y=n247
XU147 NAND2BX1TR $PINS AN=n228 B=n227 Y=n60
XU148 OAI21X1TR $PINS A0=n64 A1=n221 B0=n62 Y=n63
XU149 OAI2BB1X1TR $PINS A0N=n221 A1N=n64 B0=n63 Y=n71
XU150 XOR2X1TR $PINS A=n203 B=n196 Y=n65
XU151 XOR2X1TR $PINS A=n198 B=n65 Y=n81
XU152 AOI2BB1X1TR $PINS A0N=n194 A1N=n220 B0=n66 Y=n76
XU153 OAI21X1TR $PINS A0=n213 A1=n239 B0=n200 Y=n68
XU154 NAND2X1TR $PINS A=n213 B=n239 Y=n67
XU155 NAND2X1TR $PINS A=n68 B=n67 Y=n78
XU156 XOR2X1TR $PINS A=n76 B=n78 Y=n69
XU157 NAND2X1TR $PINS A=n71 B=n70 Y=n148
XU158 NOR2X1TR $PINS A=n71 B=n70 Y=n147
XU159 XNOR2X1TR $PINS A=n75 B=n74 Y=n80
XU160 OAI21X1TR $PINS A0=n81 A1=n78 B0=n76 Y=n77
XU161 OAI2BB1X1TR $PINS A0N=n81 A1N=n78 B0=n77 Y=n79
XU162 NAND2X1TR $PINS A=n234 B=n217 Y=n102
XU163 NOR2BX1TR $PINS AN=n102 B=n103 Y=n87
XU164 NOR2X2TR $PINS A=n88 B=n105 Y=data_out<6>
XU165 INVX1TR $PINS A=n91 Y=n93
XU166 OAI21X1TR $PINS A0=n94 A1=n93 B0=n92 Y=n95
XU167 XNOR2X1TR $PINS A=n210 B=n95 Y=n96
XU168 XNOR2X1TR $PINS A=n97 B=n96 Y=n101
XU169 AOI32X1TR $PINS A0=n201 A1=n209 A2=n207 B0=n99 B1=n98 Y=n100
XU170 OAI32X1TR $PINS A0=n136 A1=B<0> A2=n12 B0=n107 B1=n136 Y=n170
XU171 AOI22X1TR $PINS A0=B<0> A1=n118 B0=A<7> B1=n159 Y=n109
XU172 AOI22X1TR $PINS A0=A<7> A1=n137 B0=B<1> B1=n118 Y=n120
XU173 OAI22X1TR $PINS A0=n126 A1=n109 B0=n120 B1=n127 Y=n184
XU174 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n129 B0=B<5> B1=n136 Y=n110
XU175 OAI22X1TR $PINS A0=n190 A1=n110 B0=n12 B1=n114 Y=n172
XU176 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n140 B0=B<4> B1=n136 Y=n111
XU177 OAI22X1TR $PINS A0=n190 A1=n111 B0=n12 B1=n110 Y=n173
XU178 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n119 B0=B<2> B1=n136 Y=n160
XU179 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n116 B0=B<3> B1=n136 Y=n112
XU180 OAI22X1TR $PINS A0=n190 A1=n160 B0=n12 B1=n112 Y=n175
XU181 OAI22X1TR $PINS A0=n190 A1=n112 B0=n12 B1=n111 Y=n174
XU182 OAI22X1TR $PINS A0=n190 A1=n114 B0=n12 B1=n113 Y=n171
XU183 AOI22X1TR $PINS A0=A<5> A1=n119 B0=B<2> B1=n131 Y=n149
XU184 OAI22X1TR $PINS A0=n153 A1=n149 B0=n157 B1=n115 Y=n145
XU185 AOI22X1TR $PINS A0=A<7> A1=n116 B0=B<3> B1=n118 Y=n124
XU186 AOI22X1TR $PINS A0=A<7> A1=n140 B0=B<4> B1=n118 Y=n117
XU187 AOI22X1TR $PINS A0=A<7> A1=n119 B0=B<2> B1=n118 Y=n125
XU188 OAI22X1TR $PINS A0=n126 A1=n120 B0=n125 B1=n127 Y=n168
XU189 AOI22X1TR $PINS A0=B<7> A1=n142 B0=A<1> B1=n121 Y=n162
XU190 AOI2BB2X1TR $PINS A0N=n144 A1N=B<7> B0=B<7> B1=n142 Y=n122
XU191 OAI21X1TR $PINS A0=B<6> A1=n123 B0=n122 Y=n178
XU192 OAI22X1TR $PINS A0=n126 A1=n125 B0=n124 B1=n127 Y=n183
XU193 NOR2X1TR $PINS A=n159 B=n127 Y=n156
XU194 AOI22X1TR $PINS A0=B<0> A1=n131 B0=A<5> B1=n159 Y=n128
XU195 AOI22X1TR $PINS A0=A<5> A1=n137 B0=B<1> B1=n131 Y=n152
XU196 OAI22X1TR $PINS A0=n153 A1=n128 B0=n152 B1=n157 Y=n185
XU197 AOI22X1TR $PINS A0=A<5> A1=n129 B0=B<5> B1=n131 Y=n135
XU198 OAI22X1TR $PINS A0=n153 A1=n130 B0=n135 B1=n157 Y=n186
XU199 AOI22X1TR $PINS A0=A<5> A1=n132 B0=B<6> B1=n131 Y=n134
XU200 OAI22X1TR $PINS A0=n153 A1=n135 B0=n134 B1=n157 Y=n187
XU201 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n159 B0=B<0> B1=n136 Y=n139
XU202 AOI22X1TR $PINS A0=FE_OFN18_n4 A1=n137 B0=B<1> B1=n136 Y=n189
XU203 OAI22X1TR $PINS A0=n190 A1=n139 B0=n12 B1=n189 Y=n177
XU204 AOI22X1TR $PINS A0=B<5> A1=n142 B0=n141 B1=n140 Y=n143
XU205 OAI21X1TR $PINS A0=B<5> A1=n144 B0=n143 Y=n180
XU206 OAI22X1TR $PINS A0=n153 A1=n152 B0=n149 B1=n157 Y=n146
XU207 NOR2X1TR $PINS A=n159 B=n157 Y=n155
XU208 OAI22X1TR $PINS A0=n190 A1=n189 B0=n12 B1=n160 Y=n176
XU137 XOR2X1TR $PINS A=n50 B=n226 Y=n51
Xclk_r_REG98_S3 DFFQX1TR $PINS D=n151 CK=clk_clone3 Q=n227
XU13 INVX1TR $PINS A=n105 Y=n1
XU14 INVX1TR $PINS A=A<0> Y=n36
XU21 AND2X1TR $PINS A=n193 B=n211 Y=n250
.ENDS

.SUBCKT buffer_mult_1 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> wrb_data<7>
+ wrb_data<6> wrb_data<5> wrb_data<4> wrb_data<3> wrb_data<2> wrb_data<1>
+ wrb_data<0> wrb_addr<3> wrb_addr<2> wrb_addr<1> wrb_addr<0> wrb rdb_addr<3>
+ rdb_addr<2> rdb_addr<1> rdb_addr<0> data_out<7> data_out<6> data_out<5>
+ data_out<4> data_out<3> data_out<2> data_out<1> data_out<0> FE_OFN13_reset
+ FE_OFN12_reset FE_OFN10_reset FE_OFN5_reset FE_OFN16_pe_in_pk_wrb_addr__1
+ FE_OFN18_pe_in_pk_wrb_addr__0 clk_clone6 clk_clone5 clk_clone4 clk_clone3
+ clk_clone2 clk_clone1 clk
Xclk_r_REG142_S1 DFFQX1TR $PINS D=mult_A<4> CK=clk_clone2 Q=n5
Xclk_r_REG132_S1 DFFQX1TR $PINS D=mult_A<2> CK=clk_clone2 Q=n3
Xclk_r_REG120_S1 DFFQX1TR $PINS D=mult_A<1> CK=clk_clone2 Q=n2
Xclk_r_REG133_S1 DFFQX1TR $PINS D=mult_A<3> CK=clk_clone2 Q=n4
Xclk_r_REG151_S1 DFFQX1TR $PINS D=mult_A<7> CK=clk_clone2 Q=n8
Xclk_r_REG143_S1 DFFQX1TR $PINS D=mult_A<5> CK=clk_clone2 Q=n6
Xclk_r_REG150_S1 DFFQX1TR $PINS D=mult_A<6> CK=clk_clone2 Q=n7
Xclk_r_REG84_S1 DFFQX1TR $PINS D=mult_A<0> CK=clk_clone2 Q=n1
XU4 NOR2BX1TR $PINS AN=A<0> B=FE_OFN5_reset Y=mult_A<0>
XU5 NOR2BX1TR $PINS AN=A<1> B=FE_OFN5_reset Y=mult_A<1>
XU6 NOR2BX1TR $PINS AN=A<2> B=FE_OFN5_reset Y=mult_A<2>
XU7 NOR2BX1TR $PINS AN=A<3> B=FE_OFN12_reset Y=mult_A<3>
XU8 NOR2BX1TR $PINS AN=A<4> B=FE_OFN12_reset Y=mult_A<4>
XU9 NOR2BX1TR $PINS AN=A<5> B=FE_OFN12_reset Y=mult_A<5>
XU10 NOR2BX1TR $PINS AN=A<6> B=FE_OFN12_reset Y=mult_A<6>
XU11 NOR2BX1TR $PINS AN=A<7> B=FE_OFN12_reset Y=mult_A<7>
Xbuffer0 buffer_1 $PINS reset=FE_OFN10_reset wrb_data<7>=wrb_data<7>
+ wrb_data<6>=wrb_data<6> wrb_data<5>=wrb_data<5> wrb_data<4>=wrb_data<4>
+ wrb_data<3>=wrb_data<3> wrb_data<2>=wrb_data<2> wrb_data<1>=wrb_data<1>
+ wrb_data<0>=wrb_data<0> wrb_addr<3>=wrb_addr<3> wrb_addr<2>=wrb_addr<2>
+ wrb_addr<1>=wrb_addr<1> wrb_addr<0>=wrb_addr<0> wrb=wrb rdb_addr<3>=rdb_addr<3>
+ rdb_addr<2>=rdb_addr<2> rdb_addr<1>=rdb_addr<1> rdb_addr<0>=rdb_addr<0>
+ data_out<7>=buf_data<7> data_out<6>=buf_data<6> data_out<5>=buf_data<5>
+ data_out<4>=buf_data<4> data_out<3>=buf_data<3> data_out<2>=buf_data<2>
+ data_out<1>=buf_data<1> data_out<0>=buf_data<0> FE_OFN14_reset=FE_OFN13_reset
+ FE_OFN17_pe_in_pk_wrb_addr__1=FE_OFN16_pe_in_pk_wrb_addr__1
+ FE_OFN19_pe_in_pk_wrb_addr__0=FE_OFN18_pe_in_pk_wrb_addr__0
+ clk_clone3=clk_clone4 clk_clone2=clk_clone3 clk_clone1=clk_clone1 clk=clk
XMULT_single0 MULT_single_1 $PINS reset=reset A<7>=n8 A<6>=n7 A<5>=n6 A<4>=n5
+ A<3>=n4 A<2>=n3 A<1>=n2 A<0>=n1 B<7>=buf_data<7> B<6>=buf_data<6>
+ B<5>=buf_data<5> B<4>=buf_data<4> B<3>=buf_data<3> B<2>=buf_data<2>
+ B<1>=buf_data<1> B<0>=buf_data<0> data_out<7>=data_out<7>
+ data_out<6>=data_out<6> data_out<5>=data_out<5> data_out<4>=data_out<4>
+ data_out<3>=data_out<3> data_out<2>=data_out<2> data_out<1>=data_out<1>
+ data_out<0>=data_out<0> clk_clone3=clk_clone6 clk_clone2=clk_clone5
+ clk_clone1=clk_clone3 clk=clk_clone1
.ENDS

.SUBCKT buffer_0 reset wrb_data<7> wrb_data<6> wrb_data<5> wrb_data<4>
+ wrb_data<3> wrb_data<2> wrb_data<1> wrb_data<0> wrb_addr<3> wrb_addr<2>
+ wrb_addr<1> wrb_addr<0> wrb rdb_addr<3> rdb_addr<2> rdb_addr<1> rdb_addr<0>
+ data_out<7> data_out<6> data_out<5> data_out<4> data_out<3> data_out<2>
+ data_out<1> data_out<0> FE_OFN21_pe_in_pk_rdb_addr__2
+ FE_OFN23_pe_in_pk_rdb_addr__1 FE_OFN25_pe_in_pk_rdb_addr__0
+ FE_OFN31_pe_in_pk_rdb_addr__0 FE_OFN35_pe_in_pk_wrb_addr__0
+ FE_OFN37_pe_in_pk_wrb_addr__1 clk_clone2 clk_clone1 clk
XPLACEDFE_OFC119_n64 CLKBUFX2TR $PINS A=n64 Y=FE_OFN38_n64
XPLACEDFE_OFC115_n4 INVX2TR $PINS A=n4 Y=FE_DBTN1_n4
XPLACEDFE_OFC114_n4 INVX2TR $PINS A=n4 Y=FE_OFN30_FE_DBTN1_n4
XPLACEDFE_OFC93_n67 BUFX4TR $PINS A=n67 Y=FE_OFN39_n67
XPLACEDFE_OFC77_n3 CLKINVX2TR $PINS A=n3 Y=FE_DBTN2_n3
XPLACEDFE_OFC76_n3 INVX2TR $PINS A=n3 Y=FE_OFN29_FE_DBTN2_n3
XPLACEDFE_OFC67_reset INVX2TR $PINS A=reset Y=FE_DBTN12_reset
XPLACEDFE_OFC66_reset CLKINVX2TR $PINS A=reset Y=FE_OFN21_FE_DBTN12_reset
XPLACEDFE_OFC46_pe_in_pk_rdb_addr__1 CLKINVX2TR $PINS
+ A=FE_OFN23_pe_in_pk_rdb_addr__1 Y=n65
XPLACEDFE_OFC44_n17 CLKBUFX2TR $PINS A=n17 Y=FE_OFN44_n17
Xclk_r_REG324_S1 DFFQX1TR $PINS D=n186 CK=clk_clone2 Q=n292
Xclk_r_REG323_S1 DFFQX1TR $PINS D=n185 CK=clk_clone1 Q=n291
Xclk_r_REG336_S1 DFFQX1TR $PINS D=n179 CK=clk_clone1 Q=n285
Xclk_r_REG367_S1 DFFQX1TR $PINS D=n176 CK=clk_clone2 Q=n282
Xclk_r_REG366_S1 DFFQX1TR $PINS D=n175 CK=clk_clone1 Q=n281
Xclk_r_REG365_S1 DFFQX1TR $PINS D=n174 CK=clk_clone2 Q=n280
Xclk_r_REG378_S1 DFFQX1TR $PINS D=n167 CK=clk_clone2 Q=n273
Xclk_r_REG377_S1 DFFQX1TR $PINS D=n166 CK=clk_clone1 Q=n272
Xclk_r_REG376_S1 DFFQX1TR $PINS D=n165 CK=clk_clone2 Q=n271
Xclk_r_REG390_S1 DFFQX1TR $PINS D=n159 CK=clk_clone1 Q=n265
Xclk_r_REG389_S1 DFFQX1TR $PINS D=n158 CK=clk_clone2 Q=n264
Xclk_r_REG388_S1 DFFQX1TR $PINS D=n157 CK=clk_clone1 Q=n263
Xclk_r_REG387_S1 DFFQX1TR $PINS D=n156 CK=clk_clone2 Q=n262
Xclk_r_REG401_S1 DFFQX1TR $PINS D=n150 CK=clk_clone1 Q=n256
Xclk_r_REG400_S1 DFFQX1TR $PINS D=n149 CK=clk Q=n255
Xclk_r_REG399_S1 DFFQX1TR $PINS D=n148 CK=clk_clone1 Q=n254
Xclk_r_REG398_S1 DFFQX1TR $PINS D=n147 CK=clk_clone2 Q=n253
Xclk_r_REG395_S1 DFFQX1TR $PINS D=n144 CK=clk_clone1 Q=n250
Xclk_r_REG393_S1 DFFQX1TR $PINS D=n142 CK=clk_clone2 Q=n248
Xclk_r_REG412_S1 DFFQX1TR $PINS D=n141 CK=clk_clone1 Q=n247
Xclk_r_REG411_S1 DFFQX1TR $PINS D=n140 CK=clk_clone2 Q=n246
Xclk_r_REG410_S1 DFFQX1TR $PINS D=n139 CK=clk_clone1 Q=n245
Xclk_r_REG409_S1 DFFQX1TR $PINS D=n138 CK=clk_clone2 Q=n244
Xclk_r_REG407_S1 DFFQX1TR $PINS D=n136 CK=clk_clone1 Q=n242
Xclk_r_REG406_S1 DFFQX1TR $PINS D=n135 CK=clk_clone1 Q=n241
Xclk_r_REG404_S1 DFFQX1TR $PINS D=n133 CK=clk_clone2 Q=n239
Xclk_r_REG423_S1 DFFQX1TR $PINS D=n132 CK=clk_clone1 Q=n238
Xclk_r_REG422_S1 DFFQX1TR $PINS D=n131 CK=clk Q=n237
Xclk_r_REG421_S1 DFFQX1TR $PINS D=n130 CK=clk_clone1 Q=n236
Xclk_r_REG420_S1 DFFQX1TR $PINS D=n129 CK=clk Q=n235
Xclk_r_REG418_S1 DFFQX1TR $PINS D=n127 CK=clk_clone1 Q=n233
Xclk_r_REG417_S1 DFFQX1TR $PINS D=n126 CK=clk_clone1 Q=n232
Xclk_r_REG416_S1 DFFQX1TR $PINS D=n125 CK=clk_clone2 Q=n231
Xclk_r_REG415_S1 DFFQX1TR $PINS D=n124 CK=clk_clone1 Q=n230
Xclk_r_REG346_S1 DFFQX1TR $PINS D=n123 CK=clk_clone1 Q=n229
Xclk_r_REG345_S1 DFFQX1TR $PINS D=n122 CK=clk_clone1 Q=n228
Xclk_r_REG344_S1 DFFQX1TR $PINS D=n121 CK=clk_clone1 Q=n227
Xclk_r_REG343_S1 DFFQX1TR $PINS D=n120 CK=clk Q=n226
Xclk_r_REG341_S1 DFFQX1TR $PINS D=n118 CK=clk_clone1 Q=n224
Xclk_r_REG340_S1 DFFQX1TR $PINS D=n117 CK=clk_clone1 Q=n223
Xclk_r_REG339_S1 DFFQX1TR $PINS D=n116 CK=clk_clone2 Q=n222
Xclk_r_REG338_S1 DFFQX1TR $PINS D=n115 CK=clk_clone1 Q=n221
Xclk_r_REG357_S1 DFFQX1TR $PINS D=n114 CK=clk_clone1 Q=n220
Xclk_r_REG353_S1 DFFQX1TR $PINS D=n110 CK=clk_clone1 Q=n216
Xclk_r_REG352_S1 DFFQX1TR $PINS D=n109 CK=clk_clone1 Q=n215
Xclk_r_REG351_S1 DFFQX1TR $PINS D=n108 CK=clk_clone1 Q=n214
Xclk_r_REG350_S1 DFFQX1TR $PINS D=n107 CK=clk_clone2 Q=n213
Xclk_r_REG349_S1 DFFQX1TR $PINS D=n106 CK=clk_clone2 Q=n212
Xclk_r_REG369_S2 DFFQX1TR $PINS D=n315 CK=clk_clone2 Q=n210
Xclk_r_REG370_S2 DFFQX1TR $PINS D=n317 CK=clk_clone2 Q=n209
Xclk_r_REG380_S2 DFFQX1TR $PINS D=n311 CK=clk_clone2 Q=n208
Xclk_r_REG381_S2 DFFQX1TR $PINS D=n313 CK=clk_clone2 Q=n207
Xclk_r_REG391_S2 DFFQX1TR $PINS D=n308 CK=clk_clone2 Q=n206
Xclk_r_REG392_S2 DFFQX1TR $PINS D=n310 CK=clk_clone2 Q=n205
Xclk_r_REG403_S2 DFFQX1TR $PINS D=n307 CK=clk_clone2 Q=n203
Xclk_r_REG413_S2 DFFQX1TR $PINS D=n302 CK=clk_clone2 Q=n202
Xclk_r_REG414_S2 DFFQX1TR $PINS D=n304 CK=clk_clone2 Q=n201
Xclk_r_REG425_S2 DFFQX1TR $PINS D=n301 CK=clk_clone1 Q=n199
Xclk_r_REG347_S2 DFFQX1TR $PINS D=n296 CK=clk_clone1 Q=n198
Xclk_r_REG348_S2 DFFQX1TR $PINS D=n298 CK=clk_clone1 Q=n197
Xclk_r_REG358_S2 DFFQX1TR $PINS D=n293 CK=clk_clone2 Q=n196
Xclk_r_REG359_S2 DFFQX1TR $PINS D=n295 CK=clk_clone2 Q=n195
Xclk_r_REG330_S1 DFFQX1TR $PINS D=n309 CK=clk_clone1 Q=n190
Xclk_r_REG333_S1 DFFQX1TR $PINS D=n297 CK=clk_clone1 Q=n187
Xclk_r_REG327_S1 DFFQX1TR $PINS D=n300 CK=clk_clone1 Q=n193
Xclk_r_REG334_S1 DFFQX1TR $PINS D=n314 CK=clk_clone2 Q=n211
Xclk_r_REG385_S1 DFFQX1TR $PINS D=n154 CK=clk_clone1 Q=n260
Xclk_r_REG424_S2 DFFQX1TR $PINS D=n299 CK=clk Q=n200
Xclk_r_REG337_S1 DFFQX1TR $PINS D=n180 CK=clk_clone1 Q=n286
Xclk_r_REG368_S1 DFFQX1TR $PINS D=n177 CK=clk_clone1 Q=n283
Xclk_r_REG379_S1 DFFQX1TR $PINS D=n168 CK=clk_clone1 Q=n274
Xclk_r_REG361_S1 DFFQX1TR $PINS D=n170 CK=clk_clone2 Q=n276
Xclk_r_REG372_S1 DFFQX1TR $PINS D=n161 CK=clk_clone2 Q=n267
Xclk_r_REG383_S1 DFFQX1TR $PINS D=n152 CK=clk_clone2 Q=n258
Xclk_r_REG394_S1 DFFQX1TR $PINS D=n143 CK=clk_clone2 Q=n249
Xclk_r_REG405_S1 DFFQX1TR $PINS D=n134 CK=clk_clone2 Q=n240
Xclk_r_REG335_S1 DFFQX1TR $PINS D=n178 CK=clk_clone2 Q=n284
Xclk_r_REG356_S1 DFFQX1TR $PINS D=n113 CK=clk_clone2 Q=n219
Xclk_r_REG355_S1 DFFQX1TR $PINS D=n112 CK=clk_clone1 Q=n218
Xclk_r_REG354_S1 DFFQX1TR $PINS D=n111 CK=clk_clone2 Q=n217
Xclk_r_REG321_S1 DFFQX1TR $PINS D=n183 CK=clk_clone1 Q=n289
Xclk_r_REG320_S1 DFFQX1TR $PINS D=n182 CK=clk_clone1 Q=n288
Xclk_r_REG319_S1 DFFQX1TR $PINS D=n181 CK=clk_clone2 Q=n287
Xclk_r_REG363_S1 DFFQX1TR $PINS D=n172 CK=clk_clone1 Q=n278
Xclk_r_REG362_S1 DFFQX1TR $PINS D=n171 CK=clk_clone1 Q=n277
Xclk_r_REG360_S1 DFFQX1TR $PINS D=n169 CK=clk_clone2 Q=n275
Xclk_r_REG374_S1 DFFQX1TR $PINS D=n163 CK=clk_clone1 Q=n269
Xclk_r_REG373_S1 DFFQX1TR $PINS D=n162 CK=clk_clone1 Q=n268
Xclk_r_REG371_S1 DFFQX1TR $PINS D=n160 CK=clk_clone2 Q=n266
Xclk_r_REG384_S1 DFFQX1TR $PINS D=n153 CK=clk_clone1 Q=n259
Xclk_r_REG382_S1 DFFQX1TR $PINS D=n151 CK=clk_clone2 Q=n257
Xclk_r_REG396_S1 DFFQX1TR $PINS D=n145 CK=clk_clone1 Q=n251
Xclk_r_REG402_S2 DFFQX1TR $PINS D=n305 CK=clk_clone2 Q=n204
Xclk_r_REG331_S1 DFFQX1TR $PINS D=n312 CK=clk_clone2 Q=n191
Xclk_r_REG322_S1 DFFQX1TR $PINS D=n184 CK=clk_clone1 Q=n290
Xclk_r_REG328_S1 DFFQX1TR $PINS D=n303 CK=clk_clone1 Q=n188
Xclk_r_REG332_S1 DFFQX1TR $PINS D=n316 CK=clk_clone2 Q=n192
Xclk_r_REG325_S1 DFFQX1TR $PINS D=n294 CK=clk_clone1 Q=n194
Xclk_r_REG329_S1 DFFQX1TR $PINS D=n306 CK=clk Q=n189
Xclk_r_REG408_S1 DFFQX1TR $PINS D=n137 CK=clk_clone1 Q=n243
Xclk_r_REG397_S1 DFFQX1TR $PINS D=n146 CK=clk_clone1 Q=n252
Xclk_r_REG364_S1 DFFQX1TR $PINS D=n173 CK=clk_clone1 Q=n279
Xclk_r_REG342_S1 DFFQX1TR $PINS D=n119 CK=clk_clone1 Q=n225
Xclk_r_REG419_S1 DFFQX1TR $PINS D=n128 CK=clk_clone1 Q=n234
Xclk_r_REG375_S1 DFFQX1TR $PINS D=n164 CK=clk_clone1 Q=n270
Xclk_r_REG386_S1 DFFQX1TR $PINS D=n155 CK=clk_clone1 Q=n261
XU3 AO22X1TR $PINS A0=n40 A1=n44 B0=n60 B1=n246 Y=n140
XU4 AO22X1TR $PINS A0=n40 A1=n45 B0=n60 B1=n255 Y=n149
XU5 AO22X1TR $PINS A0=n40 A1=n46 B0=n60 B1=n264 Y=n158
XU6 AO22X1TR $PINS A0=n40 A1=n47 B0=n60 B1=n273 Y=n167
XU7 AO22X1TR $PINS A0=n33 A1=n48 B0=n59 B1=n280 Y=n174
XU8 AO22X1TR $PINS A0=n37 A1=n46 B0=n51 B1=n263 Y=n157
XU9 AO22X1TR $PINS A0=n33 A1=n47 B0=n59 B1=n271 Y=n165
XU10 AO22X1TR $PINS A0=n40 A1=FE_DBTN12_reset B0=n60 B1=n292 Y=n186
XU11 AO22X1TR $PINS A0=n33 A1=FE_DBTN12_reset B0=n59 B1=n291 Y=n185
XU12 AO22X1TR $PINS A0=n37 A1=FE_OFN21_FE_DBTN12_reset B0=n51 B1=n285 Y=n179
XU14 INVX2TR $PINS A=n40 Y=n60
XU15 INVX2TR $PINS A=FE_OFN44_n17 Y=n49
XU16 INVX2TR $PINS A=n37 Y=n51
XU17 NAND2X1TR $PINS A=n89 B=n88 Y=n90
XU22 NAND2X1TR $PINS A=n19 B=n188 Y=data_out<3>
XU23 OAI2BB1X1TR $PINS A0N=n202 A1N=n201 B0=n18 Y=n19
XU25 INVX2TR $PINS A=n211 Y=n18
XU27 INVX2TR $PINS A=wrb_addr<3> Y=n22
XU31 INVX2TR $PINS A=n33 Y=n59
XU32 AO22X1TR $PINS A0=n40 A1=n42 B0=n60 B1=n228 Y=n122
XU33 AO22X1TR $PINS A0=n40 A1=n43 B0=n60 B1=n237 Y=n131
XU34 AO22X1TR $PINS A0=n37 A1=n45 B0=n51 B1=n254 Y=n148
XU35 AO22X1TR $PINS A0=n40 A1=n48 B0=n60 B1=n282 Y=n176
XU38 INVX1TR $PINS A=n229 Y=n79
XU41 INVX2TR $PINS A=n15 Y=n57
XU42 NAND2X1TR $PINS A=n20 B=n190 Y=data_out<5>
XU43 AO22X1TR $PINS A0=n37 A1=n47 B0=n51 B1=n272 Y=n166
XU44 AO22X1TR $PINS A0=n37 A1=n48 B0=n51 B1=n281 Y=n175
XU45 AO22X1TR $PINS A0=n37 A1=n42 B0=n51 B1=n227 Y=n121
XU46 AO22X1TR $PINS A0=n37 A1=n43 B0=n51 B1=n236 Y=n130
XU47 AO22X1TR $PINS A0=n37 A1=n44 B0=n51 B1=n245 Y=n139
XU48 AO22X1TR $PINS A0=n33 A1=n42 B0=n59 B1=n226 Y=n120
XU49 AO22X1TR $PINS A0=n33 A1=n43 B0=n59 B1=n235 Y=n129
XU50 AO22X1TR $PINS A0=n33 A1=n44 B0=n59 B1=n244 Y=n138
XU51 AO22X1TR $PINS A0=n33 A1=n45 B0=n59 B1=n253 Y=n147
XU52 AO22X1TR $PINS A0=n33 A1=n46 B0=n59 B1=n262 Y=n156
XU53 NOR2X4TR $PINS A=n73 B=n13 Y=n12
XU54 OAI2BB1X1TR $PINS A0N=n64 A1N=n291 B0=n68 Y=n69
XU55 NAND4X1TR $PINS A=n64 B=n286 C=rdb_addr<3> D=FE_DBTN12_reset Y=n78
XU56 NOR2X1TR $PINS A=reset B=rdb_addr<3> Y=n14
XU57 OAI2BB1X1TR $PINS A0N=n206 A1N=n205 B0=n18 Y=n20
XU59 INVX2TR $PINS A=n23 Y=n52
XU60 AO22X1TR $PINS A0=n33 A1=n41 B0=n59 B1=n217 Y=n111
XU61 AO22X1TR $PINS A0=n37 A1=n41 B0=n51 B1=n218 Y=n112
XU62 AO22X1TR $PINS A0=n40 A1=n41 B0=n60 B1=n219 Y=n113
XU63 NAND2X1TR $PINS A=n12 B=FE_OFN21_pe_in_pk_rdb_addr__2 Y=n314
XU64 AOI22X1TR $PINS A0=n103 A1=n99 B0=n238 B1=n104 Y=n300
XU65 AOI22X1TR $PINS A0=n104 A1=n265 B0=n103 B1=n90 Y=n309
XU66 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n41 B0=n49 B1=n213 Y=n107
XU67 NAND2X1TR $PINS A=n57 B=n216 Y=n16
XU68 AO22X1TR $PINS A0=n23 A1=n41 B0=n52 B1=n220 Y=n114
XU69 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n42 B0=n49 B1=n222 Y=n116
XU70 OR2X2TR $PINS A=FE_OFN31_pe_in_pk_rdb_addr__0 B=n65 Y=n3
XU71 NOR2X2TR $PINS A=FE_OFN25_pe_in_pk_rdb_addr__0
+ B=FE_OFN23_pe_in_pk_rdb_addr__1 Y=n67
XU72 NAND2X1TR $PINS A=FE_OFN31_pe_in_pk_rdb_addr__0
+ B=FE_OFN23_pe_in_pk_rdb_addr__1 Y=n4
XU73 NOR2BX1TR $PINS AN=wrb_data<2> B=reset Y=n43
XU74 NOR2BX1TR $PINS AN=wrb_data<3> B=reset Y=n44
XU75 NOR2BX2TR $PINS AN=wrb_data<4> B=reset Y=n45
XU76 NOR2BX1TR $PINS AN=wrb_data<5> B=reset Y=n46
XU77 NOR2BX2TR $PINS AN=wrb_data<6> B=reset Y=n47
XU78 NOR2BX1TR $PINS AN=wrb_data<7> B=reset Y=n48
XU85 AND2X8TR $PINS A=n12 B=n74 Y=n103
XU86 NAND2BX4TR $PINS AN=n72 B=n14 Y=n13
XU87 OAI21X1TR $PINS A0=n22 A1=n38 B0=FE_DBTN12_reset Y=n23
XU88 AOI211X2TR $PINS A0=n292 A1=FE_DBTN2_n3 B0=n74 C0=n69 Y=n73
XU89 NOR2X2TR $PINS A=FE_OFN23_pe_in_pk_rdb_addr__1 B=rdb_addr<0> Y=n64
XU90 OAI21X1TR $PINS A0=n21 A1=n22 B0=wrb Y=n38
XU91 INVX2TR $PINS A=n104 Y=n80
XU92 CLKINVX2TR $PINS A=FE_OFN37_pe_in_pk_wrb_addr__1 Y=n31
XU93 CLKINVX2TR $PINS A=wrb_addr<2> Y=n25
XU94 NAND2BX1TR $PINS AN=FE_OFN35_pe_in_pk_wrb_addr__0 B=n25 Y=n35
XU95 NAND2X1TR $PINS A=wrb B=n22 Y=n34
XU96 NOR2BX1TR $PINS AN=wrb_data<0> B=reset Y=n41
XU97 OAI2BB1X1TR $PINS A0N=n15 A1N=n41 B0=n16 Y=n110
XU98 NAND2X1TR $PINS A=FE_OFN37_pe_in_pk_wrb_addr__1 B=wrb_addr<2> Y=n39
XU99 NAND3X1TR $PINS A=wrb B=wrb_addr<0> C=n22 Y=n29
XU100 OAI21X1TR $PINS A0=n39 A1=n29 B0=FE_DBTN12_reset Y=n17
XU101 NOR2BX1TR $PINS AN=wrb_data<1> B=reset Y=n42
XU102 NOR3X1TR $PINS A=wrb_addr<1> B=wrb_addr<2> C=wrb_addr<0> Y=n21
XU103 AOI32X4TR $PINS A0=n195 A1=n194 A2=n196 B0=n211 B1=n194 Y=data_out<0>
XU104 AOI32X1TR $PINS A0=n209 A1=n192 A2=n210 B0=n211 B1=n192 Y=data_out<7>
XU105 AOI32X1TR $PINS A0=n207 A1=n191 A2=n208 B0=n211 B1=n191 Y=data_out<6>
XU106 AOI32X1TR $PINS A0=n197 A1=n187 A2=n198 B0=n211 B1=n187 Y=data_out<1>
XU107 AOI32X1TR $PINS A0=n203 A1=n189 A2=n204 B0=n211 B1=n189 Y=data_out<4>
XU108 AOI32X1TR $PINS A0=n199 A1=n193 A2=n200 B0=n211 B1=n193 Y=data_out<2>
XU109 OAI31X4TR $PINS A0=FE_OFN37_pe_in_pk_wrb_addr__1 A1=n25 A2=n29
+ B0=FE_DBTN12_reset Y=n26
XU110 INVX2TR $PINS A=n26 Y=n54
XU111 AO22X1TR $PINS A0=n26 A1=n41 B0=n54 B1=n212 Y=n106
XU112 OAI31X4TR $PINS A0=wrb_addr<2> A1=n31 A2=n29 B0=FE_OFN21_FE_DBTN12_reset
+ Y=n27
XU113 INVX2TR $PINS A=n27 Y=n55
XU114 AO22X1TR $PINS A0=n27 A1=n41 B0=n55 B1=n214 Y=n108
XU115 OAI31X4TR $PINS A0=FE_OFN37_pe_in_pk_wrb_addr__1 A1=n29 A2=wrb_addr<2>
+ B0=FE_OFN21_FE_DBTN12_reset Y=n30
XU116 INVX2TR $PINS A=n30 Y=n56
XU117 AO22X1TR $PINS A0=n30 A1=n41 B0=n56 B1=n215 Y=n109
XU118 NAND2X1TR $PINS A=wrb_addr<2> B=n31 Y=n32
XU119 OAI31X4TR $PINS A0=wrb_addr<0> A1=n34 A2=n32 B0=FE_DBTN12_reset Y=n33
XU120 OAI31X4TR $PINS A0=FE_OFN37_pe_in_pk_wrb_addr__1 A1=n35 A2=n34
+ B0=FE_OFN21_FE_DBTN12_reset Y=n37
XU121 OAI31X4TR $PINS A0=wrb_addr<0> A1=n39 A2=n38 B0=FE_DBTN12_reset Y=n40
XU123 AO22X1TR $PINS A0=n26 A1=n42 B0=n54 B1=n221 Y=n115
XU124 AO22X1TR $PINS A0=n27 A1=n42 B0=n55 B1=n223 Y=n117
XU125 AO22X1TR $PINS A0=n30 A1=n42 B0=n56 B1=n224 Y=n118
XU126 AO22X1TR $PINS A0=n15 A1=n42 B0=n57 B1=n225 Y=n119
XU127 AOI2BB2X1TR $PINS A0N=n52 A1N=n42 B0=n79 B1=n52 Y=n123
XU128 AO22X1TR $PINS A0=n26 A1=n43 B0=n54 B1=n230 Y=n124
XU129 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n43 B0=n49 B1=n231 Y=n125
XU130 AO22X1TR $PINS A0=n27 A1=n43 B0=n55 B1=n232 Y=n126
XU131 AO22X1TR $PINS A0=n30 A1=n43 B0=n56 B1=n233 Y=n127
XU132 AO22X1TR $PINS A0=n15 A1=n43 B0=n57 B1=n234 Y=n128
XU133 AO22X1TR $PINS A0=n23 A1=n43 B0=n52 B1=n238 Y=n132
XU134 AO22X1TR $PINS A0=n26 A1=n44 B0=n54 B1=n239 Y=n133
XU135 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n44 B0=n49 B1=n240 Y=n134
XU136 AO22X1TR $PINS A0=n27 A1=n44 B0=n55 B1=n241 Y=n135
XU137 AO22X1TR $PINS A0=n30 A1=n44 B0=n56 B1=n242 Y=n136
XU138 AO22X1TR $PINS A0=n15 A1=n44 B0=n57 B1=n243 Y=n137
XU139 AO22X1TR $PINS A0=n23 A1=n44 B0=n52 B1=n247 Y=n141
XU140 AO22X1TR $PINS A0=n26 A1=n45 B0=n54 B1=n248 Y=n142
XU141 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n45 B0=n49 B1=n249 Y=n143
XU142 AO22X1TR $PINS A0=n27 A1=n45 B0=n55 B1=n250 Y=n144
XU143 AO22X1TR $PINS A0=n30 A1=n45 B0=n56 B1=n251 Y=n145
XU144 AO22X1TR $PINS A0=n15 A1=n45 B0=n57 B1=n252 Y=n146
XU145 AO22X1TR $PINS A0=n23 A1=n45 B0=n52 B1=n256 Y=n150
XU146 AO22X1TR $PINS A0=n26 A1=n46 B0=n54 B1=n257 Y=n151
XU147 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n46 B0=n49 B1=n258 Y=n152
XU148 AO22X1TR $PINS A0=n27 A1=n46 B0=n55 B1=n259 Y=n153
XU149 AO22X1TR $PINS A0=n30 A1=n46 B0=n56 B1=n260 Y=n154
XU150 AO22X1TR $PINS A0=n15 A1=n46 B0=n57 B1=n261 Y=n155
XU151 AO22X1TR $PINS A0=n23 A1=n46 B0=n52 B1=n265 Y=n159
XU152 AO22X1TR $PINS A0=n26 A1=n47 B0=n54 B1=n266 Y=n160
XU153 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n47 B0=n49 B1=n267 Y=n161
XU154 AO22X1TR $PINS A0=n27 A1=n47 B0=n55 B1=n268 Y=n162
XU155 AO22X1TR $PINS A0=n30 A1=n47 B0=n56 B1=n269 Y=n163
XU156 AO22X1TR $PINS A0=n15 A1=n47 B0=n57 B1=n270 Y=n164
XU157 AO22X1TR $PINS A0=n23 A1=n47 B0=n52 B1=n274 Y=n168
XU158 AO22X1TR $PINS A0=n26 A1=n48 B0=n54 B1=n275 Y=n169
XU159 AO22X1TR $PINS A0=FE_OFN44_n17 A1=n48 B0=n49 B1=n276 Y=n170
XU160 AO22X1TR $PINS A0=n27 A1=n48 B0=n55 B1=n277 Y=n171
XU161 AO22X1TR $PINS A0=n30 A1=n48 B0=n56 B1=n278 Y=n172
XU162 AO22X1TR $PINS A0=n15 A1=n48 B0=n57 B1=n279 Y=n173
XU163 AO22X1TR $PINS A0=n23 A1=n48 B0=n52 B1=n283 Y=n177
XU164 AO22X1TR $PINS A0=FE_OFN44_n17 A1=FE_DBTN12_reset B0=n49 B1=n284 Y=n178
XU165 AO22X1TR $PINS A0=n23 A1=FE_DBTN12_reset B0=n52 B1=n286 Y=n180
XU166 AO22X1TR $PINS A0=n26 A1=FE_DBTN12_reset B0=n54 B1=n287 Y=n181
XU167 AO22X1TR $PINS A0=n27 A1=FE_OFN21_FE_DBTN12_reset B0=n55 B1=n288 Y=n182
XU168 AO22X1TR $PINS A0=n30 A1=FE_OFN21_FE_DBTN12_reset B0=n56 B1=n289 Y=n183
XU169 AO22X1TR $PINS A0=n15 A1=FE_OFN21_FE_DBTN12_reset B0=n57 B1=n290 Y=n184
XU171 AOI22X2TR $PINS A0=FE_OFN39_n67 A1=n289 B0=FE_OFN29_FE_DBTN2_n3 B1=n290
+ Y=n70
XU172 OAI2BB1X2TR $PINS A0N=FE_OFN30_FE_DBTN1_n4 A1N=n288 B0=n70 Y=n71
XU173 AOI211X1TR $PINS A0=n64 A1=n285 B0=FE_OFN21_pe_in_pk_rdb_addr__2 C0=n71
+ Y=n72
XU174 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n223 B0=FE_OFN39_n67 B1=n224
+ Y=n76
XU175 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n227 B0=FE_OFN29_FE_DBTN2_n3 B1=n225
+ Y=n75
XU176 NAND2X1TR $PINS A=n76 B=n75 Y=n81
XU177 NOR2X2TR $PINS A=FE_OFN21_pe_in_pk_rdb_addr__2 B=n78 Y=n104
XU178 AOI2BB2X1TR $PINS A0N=n80 A1N=n79 B0=n103 B1=n81 Y=n297
XU179 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n241 B0=FE_OFN39_n67 B1=n242
+ Y=n83
XU180 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n245 B0=FE_OFN29_FE_DBTN2_n3 B1=n243
+ Y=n82
XU181 NAND2X1TR $PINS A=n83 B=n82 Y=n84
XU182 AOI22X1TR $PINS A0=n104 A1=n247 B0=n103 B1=n84 Y=n303
XU183 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n250 B0=FE_OFN39_n67 B1=n251
+ Y=n86
XU184 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n254 B0=FE_OFN29_FE_DBTN2_n3 B1=n252
+ Y=n85
XU185 NAND2X1TR $PINS A=n86 B=n85 Y=n87
XU186 AOI22X1TR $PINS A0=n104 A1=n256 B0=n103 B1=n87 Y=n306
XU187 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n259 B0=FE_OFN39_n67 B1=n260
+ Y=n89
XU188 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n263 B0=FE_OFN29_FE_DBTN2_n3 B1=n261
+ Y=n88
XU189 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n268 B0=FE_OFN39_n67 B1=n269
+ Y=n92
XU190 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n272 B0=FE_OFN29_FE_DBTN2_n3 B1=n270
+ Y=n91
XU191 NAND2X1TR $PINS A=n92 B=n91 Y=n93
XU192 AOI22X1TR $PINS A0=n104 A1=n274 B0=n103 B1=n93 Y=n312
XU193 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n277 B0=FE_OFN39_n67 B1=n278
+ Y=n95
XU194 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n281 B0=FE_OFN29_FE_DBTN2_n3 B1=n279
+ Y=n94
XU195 NAND2X1TR $PINS A=n95 B=n94 Y=n96
XU196 AOI22X1TR $PINS A0=n104 A1=n283 B0=n103 B1=n96 Y=n316
XU197 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n232 B0=FE_OFN39_n67 B1=n233
+ Y=n98
XU198 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n236 B0=FE_OFN29_FE_DBTN2_n3 B1=n234
+ Y=n97
XU199 NAND2X1TR $PINS A=n98 B=n97 Y=n99
XU200 AOI22X1TR $PINS A0=FE_OFN30_FE_DBTN1_n4 A1=n214 B0=FE_OFN39_n67 B1=n215
+ Y=n101
XU201 AOI22X1TR $PINS A0=FE_OFN38_n64 A1=n218 B0=FE_OFN29_FE_DBTN2_n3 B1=n216
+ Y=n100
XU202 NAND2X1TR $PINS A=n101 B=n100 Y=n102
XU203 AOI22X1TR $PINS A0=n104 A1=n220 B0=n103 B1=n102 Y=n294
XU204 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n213 B0=FE_OFN39_n67 B1=n212 Y=n295
XU205 AOI22X1TR $PINS A0=n64 A1=n217 B0=FE_DBTN2_n3 B1=n219 Y=n293
XU206 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n222 B0=FE_OFN39_n67 B1=n221 Y=n298
XU207 AOI22X1TR $PINS A0=n64 A1=n226 B0=FE_DBTN2_n3 B1=n228 Y=n296
XU208 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n231 B0=FE_OFN39_n67 B1=n230 Y=n301
XU209 AOI22X1TR $PINS A0=n64 A1=n235 B0=FE_DBTN2_n3 B1=n237 Y=n299
XU210 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n240 B0=n67 B1=n239 Y=n304
XU211 AOI22X1TR $PINS A0=n64 A1=n244 B0=FE_DBTN2_n3 B1=n246 Y=n302
XU212 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n249 B0=n67 B1=n248 Y=n307
XU213 AOI22X1TR $PINS A0=n64 A1=n253 B0=FE_DBTN2_n3 B1=n255 Y=n305
XU214 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n258 B0=n67 B1=n257 Y=n310
XU215 AOI22X1TR $PINS A0=n64 A1=n262 B0=FE_DBTN2_n3 B1=n264 Y=n308
XU216 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n267 B0=n67 B1=n266 Y=n313
XU217 AOI22X1TR $PINS A0=n64 A1=n271 B0=FE_DBTN2_n3 B1=n273 Y=n311
XU218 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n276 B0=n67 B1=n275 Y=n317
XU219 AOI22X1TR $PINS A0=n64 A1=n280 B0=FE_DBTN2_n3 B1=n282 Y=n315
XU40 AOI22X1TR $PINS A0=FE_DBTN1_n4 A1=n284 B0=FE_OFN39_n67 B1=n287 Y=n68
XU37 OAI31X4TR $PINS A0=n31 A1=n35 A2=n34 B0=FE_OFN21_FE_DBTN12_reset Y=n15
XU20 INVX1TR $PINS A=FE_OFN21_pe_in_pk_rdb_addr__2 Y=n74
.ENDS

.SUBCKT MULT_single_0 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> B<7> B<6>
+ B<5> B<4> B<3> B<2> B<1> B<0> data_out<7> data_out<6> data_out<5> data_out<4>
+ data_out<3> data_out<2> data_out<1> data_out<0> clk_clone2 clk_clone1 clk
XPLACEDFE_DBTC0_n255 INVX1TR $PINS A=n255 Y=FE_DBTN0_n255
Xclk_r_REG326_S2 DFFQX1TR $PINS D=B<0> CK=clk Q=n253
Xclk_r_REG298_S2 DFFQX1TR $PINS D=n264 CK=clk Q=n252
Xclk_r_REG301_S2 DFFQX1TR $PINS D=n155 CK=clk Q=n249
Xclk_r_REG311_S2 DFFQX1TR $PINS D=n156 CK=clk_clone1 Q=n248
Xclk_r_REG283_S3 DFFQX1TR $PINS D=n158 CK=clk_clone2 Q=n246
Xclk_r_REG280_S3 DFFQX1TR $PINS D=n80 CK=clk_clone2 Q=n244
Xclk_r_REG270_S3 DFFQX1TR $PINS D=n148 CK=clk Q=n243
Xclk_r_REG268_S3 DFFQX1TR $PINS D=n259 CK=clk Q=n242
Xclk_r_REG269_S3 DFFQX1TR $PINS D=n260 CK=clk Q=n241
Xclk_r_REG265_S3 DFFQX1TR $PINS D=n150 CK=clk Q=n240
Xclk_r_REG266_S3 DFFQX1TR $PINS D=n151 CK=clk Q=n239
Xclk_r_REG263_S3 DFFQX1TR $PINS D=n257 CK=clk Q=n238
Xclk_r_REG271_S3 DFFQX1TR $PINS D=n147 CK=clk Q=n236
Xclk_r_REG262_S2 DFFQX1TR $PINS D=n181 CK=clk Q=n235
Xclk_r_REG267_S2 DFFQX1TR $PINS D=n180 CK=clk Q=n234
Xclk_r_REG272_S2 DFFQX1TR $PINS D=n182 CK=clk Q=n233
Xclk_r_REG277_S2 DFFQX1TR $PINS D=n179 CK=clk Q=n232
Xclk_r_REG284_S2 DFFQX1TR $PINS D=n263 CK=clk Q=n230
Xclk_r_REG296_S2 DFFQX1TR $PINS D=n161 CK=clk_clone1 Q=n229
Xclk_r_REG281_S3 DFFQX1TR $PINS D=n79 CK=clk Q=n227
Xclk_r_REG276_S3 DFFQX1TR $PINS D=n256 CK=clk Q=n226
Xclk_r_REG274_S3 DFFQX1TR $PINS D=n258 CK=clk Q=n225
Xclk_r_REG289_S2 DFFQX1TR $PINS D=n176 CK=clk Q=n224
Xclk_r_REG286_S2 DFFQX1TR $PINS D=n154 CK=clk Q=n222
Xclk_r_REG290_S2 DFFQX1TR $PINS D=n177 CK=clk Q=n221
Xclk_r_REG305_S2 DFFQX1TR $PINS D=n186 CK=clk_clone1 Q=n219
Xclk_r_REG312_S2 DFFQX1TR $PINS D=n183 CK=clk_clone1 Q=n217
Xclk_r_REG314_S2 DFFQX1TR $PINS D=n167 CK=clk_clone1 Q=n214
Xclk_r_REG307_S2 DFFQX1TR $PINS D=n145 CK=clk_clone1 Q=n213
Xclk_r_REG291_S2 DFFQX1TR $PINS D=n171 CK=clk_clone1 Q=n211
Xclk_r_REG293_S2 DFFQX1TR $PINS D=n175 CK=clk Q=n209
Xclk_r_REG303_S2 DFFQX1TR $PINS D=n169 CK=clk Q=n205
Xclk_r_REG297_S2 DFFQX1TR $PINS D=n170 CK=clk Q=n203
Xclk_r_REG428_S2 DFFQX1TR $PINS D=FE_DBTN0_n255 CK=clk_clone2 Q=n250
Xclk_r_REG285_S3 DFFQX1TR $PINS D=n202 CK=clk Q=n251
Xclk_r_REG278_S2 DFFQX1TR $PINS D=n178 CK=clk_clone2 Q=n231
Xclk_r_REG279_S3 DFFQX1TR $PINS D=n165 CK=clk_clone2 Q=n228
Xclk_r_REG287_S2 DFFQX1TR $PINS D=n162 CK=clk_clone2 Q=n216
Xclk_r_REG315_S2 DFFQX1TR $PINS D=n166 CK=clk_clone1 Q=n204
Xclk_r_REG308_S2 DFFQX1TR $PINS D=n188 CK=clk_clone1 Q=n212
Xclk_r_REG304_S2 DFFQX1TR $PINS D=n187 CK=clk_clone1 Q=n220
Xclk_r_REG306_S2 DFFQX1TR $PINS D=n185 CK=clk Q=n218
Xclk_r_REG316_S2 DFFQX1TR $PINS D=n184 CK=clk_clone1 Q=n206
Xclk_r_REG313_S2 DFFQX1TR $PINS D=n168 CK=clk_clone1 Q=n215
Xclk_r_REG292_S2 DFFQX1TR $PINS D=n174 CK=clk Q=n210
Xclk_r_REG273_S3 DFFQX1TR $PINS D=n261 CK=clk Q=n247
Xclk_r_REG275_S3 DFFQX1TR $PINS D=n262 CK=clk Q=n237
Xclk_r_REG426_S1 DFFQX1TR $PINS D=reset CK=clk Q=n255
Xclk_r_REG282_S3 DFFQX1TR $PINS D=n164 CK=clk_clone1 Q=n245
Xclk_r_REG295_S2 DFFQX1TR $PINS D=n172 CK=clk_clone1 Q=n207
Xclk_r_REG302_S2 DFFQX1TR $PINS D=n146 CK=clk Q=n223
Xclk_r_REG294_S2 DFFQX1TR $PINS D=n173 CK=clk_clone2 Q=n208
XU1 AO21X1TR $PINS A0=n13 A1=n200 B0=n119 Y=n161
XU2 NOR2X1TR $PINS A=n262 B=n202 Y=n86
XU3 INVX2TR $PINS A=B<0> Y=n196
XU5 INVX2TR $PINS A=B<1> Y=n152
XU6 INVX2TR $PINS A=A<5> Y=n140
XU7 XOR2X1TR $PINS A=n72 B=n71 Y=n73
XU8 NOR2X1TR $PINS A=n217 B=n211 Y=n110
XU9 OR3X1TR $PINS A=n237 B=n247 C=n251 Y=n9
XU10 NAND2X1TR $PINS A=n244 B=n227 Y=n68
XU11 XOR2X1TR $PINS A=n36 B=n238 Y=n37
XU12 INVX2TR $PINS A=n226 Y=n39
XU13 CLKINVX2TR $PINS A=B<5> Y=n138
XU14 XOR2X1TR $PINS A=n58 B=n12 Y=n18
XU15 OA21XLTR $PINS A0=n33 A1=n222 B0=n32 Y=n202
XU16 NOR2X1TR $PINS A=n233 B=n35 Y=n262
XU17 CLKINVX2TR $PINS A=A<0> Y=n34
XU18 XOR2X1TR $PINS A=n53 B=n52 Y=n54
XU19 INVX1TR $PINS A=n123 Y=n124
XU20 AND2X2TR $PINS A=n233 B=n35 Y=n261
XU21 INVX1TR $PINS A=n87 Y=n88
XU22 NOR2X1TR $PINS A=n64 B=n7 Y=n6
XU23 INVX2TR $PINS A=A<7> Y=n127
XU24 AND2X2TR $PINS A=n203 B=n221 Y=n87
XU26 OR2X2TR $PINS A=n212 B=n215 Y=n101
XU27 NOR3X1TR $PINS A=A<5> B=A<6> C=n127 Y=n123
XU28 AOI2BB2X1TR $PINS A0N=n140 A1N=B<4> B0=B<4> B1=n140 Y=n139
XU29 AO22X1TR $PINS A0=A<3> A1=n113 B0=n14 B1=n149 Y=n200
XU30 XNOR2X1TR $PINS A=n95 B=n94 Y=n80
XU31 XOR2X1TR $PINS A=n27 B=n109 Y=n102
XU32 AOI2BB2X1TR $PINS A0N=n189 A1N=B<7> B0=B<7> B1=n160 Y=n131
XU33 AOI22X1TR $PINS A0=A<5> A1=n138 B0=B<5> B1=n140 Y=n144
XU35 NOR2X4TR $PINS A=n46 B=n84 Y=data_out<5>
XU36 OAI2BB1X1TR $PINS A0N=n207 A1N=n216 B0=n28 Y=n100
XU37 OAI21X1TR $PINS A0=n216 A1=n207 B0=n60 Y=n28
XU38 AND4X4TR $PINS A=n17 B=n9 C=n16 D=FE_DBTN0_n255 Y=data_out<0>
XU39 NOR2X1TR $PINS A=n19 B=n18 Y=n260
XU40 NOR3X1TR $PINS A=A<3> B=A<4> C=n140 Y=n121
XU41 XNOR2X2TR $PINS A=n82 B=n4 Y=n69
XU42 NAND2BX1TR $PINS AN=n81 B=n78 Y=n4
XU43 NAND2X1TR $PINS A=n228 B=n245 Y=n78
XU45 CLKINVX2TR $PINS A=n132 Y=n159
XU46 AND2X2TR $PINS A=n243 B=n236 Y=n7
XU48 NOR2X2TR $PINS A=n69 B=n84 Y=data_out<6>
XU49 OAI21X1TR $PINS A0=n237 A1=n247 B0=n251 Y=n17
XU50 INVX1TR $PINS A=n254 Y=n16
XU51 INVX1TR $PINS A=B<6> Y=n141
XU52 OR2X1TR $PINS A=A<2> B=A<1> Y=n113
XU53 INVX1TR $PINS A=B<7> Y=n130
XU54 INVX2TR $PINS A=A<3> Y=n149
XU55 AOI2BB1X1TR $PINS A0N=n203 A1N=n221 B0=n87 Y=n35
XU56 XOR2X1TR $PINS A=n25 B=n24 Y=n31
XU57 XOR2X1TR $PINS A=n99 B=n63 Y=n90
XU58 XNOR2X1TR $PINS A=n220 B=n106 Y=n107
XU59 OAI21X1TR $PINS A0=n82 A1=n81 B0=n78 Y=n83
XU60 INVX1TR $PINS A=n121 Y=n48
XU61 OAI21X1TR $PINS A0=B<3> A1=n189 B0=n20 Y=n182
XU62 NAND2X1TR $PINS A=n19 B=n18 Y=n259
XU63 XOR2X1TR $PINS A=n93 B=n92 Y=n95
XU64 CLKINVX1TR $PINS A=n13 Y=n264
XU65 OAI31X1TR $PINS A0=n136 A1=n127 A2=B<0> B0=n124 Y=n166
XU66 OAI21X1TR $PINS A0=A<5> A1=A<6> B0=n114 Y=n136
XU67 NOR2X1TR $PINS A=n228 B=n245 Y=n81
XU68 AND2X2TR $PINS A=n5 B=n68 Y=n82
XU69 OAI21X1TR $PINS A0=n67 A1=n8 B0=n6 Y=n5
XU70 OR2X2TR $PINS A=n66 B=n65 Y=n8
XU71 OAI21X1TR $PINS A0=n241 A1=n239 B0=n242 Y=n66
XU72 AND2X4TR $PINS A=n40 B=n70 Y=n67
XU73 OAI21X1TR $PINS A0=n102 A1=n101 B0=n100 Y=n103
XU74 AOI31X1TR $PINS A0=A<6> A1=A<5> A2=n127 B0=n123 Y=n134
XU75 XOR2X1TR $PINS A=n76 B=n70 Y=n77
XU76 NAND2X1TR $PINS A=A<2> B=A<1> Y=n14
XU77 AND2X2TR $PINS A=n234 B=n205 Y=n58
XU78 AO21X1TR $PINS A0=n94 A1=n93 B0=n23 Y=n165
XU79 AOI2BB1X1TR $PINS A0N=n234 A1N=n205 B0=n58 Y=n25
XU80 OAI21X1TR $PINS A0=n209 A1=n218 B0=n25 Y=n10
XU81 OAI2BB1X1TR $PINS A0N=n218 A1N=n209 B0=n10 Y=n19
XU82 XOR2X1TR $PINS A=n223 B=n248 Y=n11
XU83 XOR2X1TR $PINS A=n11 B=n210 Y=n56
XU84 XOR2X1TR $PINS A=n232 B=n56 Y=n12
XU85 OAI21X1TR $PINS A0=A<2> A1=A<1> B0=n14 Y=n13
XU87 OAI22X1TR $PINS A0=n149 A1=n130 B0=B<7> B1=A<3> Y=n119
XU89 NAND2X1TR $PINS A=A<1> B=A<0> Y=n189
XU90 NOR2X1TR $PINS A=A<1> B=n34 Y=n160
XU91 NAND2X1TR $PINS A=n34 B=A<1> Y=n132
XU92 CLKINVX2TR $PINS A=B<2> Y=n128
XU93 AOI22X1TR $PINS A0=B<3> A1=n160 B0=n159 B1=n128 Y=n20
XU94 AND2X2TR $PINS A=n231 B=n204 Y=n60
XU95 XOR2X1TR $PINS A=n207 B=n60 Y=n21
XU96 XOR2X1TR $PINS A=n21 B=n216 Y=n94
XU97 OAI21X1TR $PINS A0=n208 A1=n213 B0=n206 Y=n22
XU98 OAI2BB1X1TR $PINS A0N=n213 A1N=n208 B0=n22 Y=n93
XU99 INVX1TR $PINS A=n101 Y=n105
XU100 AOI21X1TR $PINS A0=n215 A1=n212 B0=n105 Y=n92
XU101 AOI2BB1X1TR $PINS A0N=n94 A1N=n93 B0=n92 Y=n23
XU102 XOR2X1TR $PINS A=n209 B=n218 Y=n24
XU103 OAI21X1TR $PINS A0=n235 A1=n249 B0=n224 Y=n26
XU104 OAI2BB1X1TR $PINS A0N=n249 A1N=n235 B0=n26 Y=n30
XU105 NOR2X1TR $PINS A=n31 B=n30 Y=n150
XU106 AOI21X1TR $PINS A0=n211 A1=n217 B0=n110 Y=n27
XU107 CLKINVX2TR $PINS A=n219 Y=n109
XU108 XOR2X1TR $PINS A=n100 B=n101 Y=n29
XU109 XOR2X1TR $PINS A=n102 B=n29 Y=n164
XU110 NAND2X1TR $PINS A=n31 B=n30 Y=n151
XU111 AOI21X1TR $PINS A0=n252 A1=n253 B0=n230 Y=n33
XU112 NAND3X1TR $PINS A=n253 B=n252 C=n230 Y=n32
XU113 OAI211X1TR $PINS A0=n152 A1=n34 B0=A<1> C0=n196 Y=n154
XU114 NOR2X1TR $PINS A=n225 B=n226 Y=n36
XU115 NOR2X1TR $PINS A=n37 B=n254 Y=n38
XU117 OAI21X2TR $PINS A0=n225 A1=n238 B0=n39 Y=n70
XU118 NOR2X1TR $PINS A=n241 B=n240 Y=n40
XU120 INVX1TR $PINS A=n236 Y=n41
XU121 INVX2TR $PINS A=n243 Y=n65
XU122 AOI21X1TR $PINS A0=n41 A1=n66 B0=n65 Y=n42
XU123 OAI21X1TR $PINS A0=n43 A1=n236 B0=n42 Y=n45
XU124 NOR2X1TR $PINS A=n244 B=n227 Y=n64
XU125 NAND2BX1TR $PINS AN=n64 B=n68 Y=n44
XU126 XOR2X2TR $PINS A=n45 B=n44 Y=n46
XU127 NAND2BX1TR $PINS AN=n255 B=n250 Y=n84
XU128 NAND2X1TR $PINS A=A<3> B=A<4> Y=n47
XU129 OAI21X1TR $PINS A0=A<3> A1=A<4> B0=n47 Y=n195
XU130 OAI31X1TR $PINS A0=n195 A1=n140 A2=B<0> B0=n48 Y=n169
XU131 AOI22X1TR $PINS A0=n160 A1=B<6> B0=n159 B1=n138 Y=n49
XU132 OAI21X1TR $PINS A0=B<6> A1=n189 B0=n49 Y=n179
XU133 CLKINVX2TR $PINS A=B<3> Y=n125
XU134 AOI22X1TR $PINS A0=B<4> A1=n160 B0=n159 B1=n125 Y=n50
XU135 OAI21X1TR $PINS A0=B<4> A1=n189 B0=n50 Y=n181
XU136 AOI22X1TR $PINS A0=n160 A1=B<2> B0=n159 B1=n152 Y=n51
XU137 OAI21X1TR $PINS A0=B<2> A1=n189 B0=n51 Y=n263
XU138 NOR2X2TR $PINS A=n67 B=n66 Y=n53
XU139 NOR2X1TR $PINS A=n236 B=n65 Y=n52
XU140 OR2X2TR $PINS A=n84 B=n54 Y=n55
XU141 CLKINVX4TR $PINS A=n55 Y=data_out<4>
XU142 OAI21X1TR $PINS A0=n58 A1=n232 B0=n56 Y=n57
XU143 OAI2BB1X1TR $PINS A0N=n232 A1N=n58 B0=n57 Y=n91
XU144 XOR2X1TR $PINS A=n213 B=n206 Y=n59
XU145 XOR2X1TR $PINS A=n208 B=n59 Y=n99
XU146 AOI2BB1X1TR $PINS A0N=n204 A1N=n231 B0=n60 Y=n96
XU147 OAI21X1TR $PINS A0=n223 A1=n248 B0=n210 Y=n62
XU148 NAND2X1TR $PINS A=n223 B=n248 Y=n61
XU149 NAND2X1TR $PINS A=n62 B=n61 Y=n98
XU150 XOR2X1TR $PINS A=n96 B=n98 Y=n63
XU151 NOR2X1TR $PINS A=n91 B=n90 Y=n147
XU152 NAND2BX1TR $PINS AN=n241 B=n242 Y=n72
XU153 INVX2TR $PINS A=n70 Y=n74
XU154 OAI21X1TR $PINS A0=n240 A1=n74 B0=n239 Y=n71
XU155 NOR2X2TR $PINS A=n73 B=n84 Y=data_out<3>
XU156 NAND2BX1TR $PINS AN=n240 B=n239 Y=n76
XU157 NOR2X1TR $PINS A=n77 B=n84 Y=data_out<2>
XU158 XOR2X1TR $PINS A=n83 B=n246 Y=n85
XU159 NOR2X1TR $PINS A=n85 B=n84 Y=data_out<7>
XU160 NOR3X1TR $PINS A=n261 B=n87 C=n86 Y=n258
XU161 NOR3BX1TR $PINS AN=n233 B=n202 C=n88 Y=n256
XU162 XOR2X1TR $PINS A=n249 B=n224 Y=n89
XU163 XNOR2X1TR $PINS A=n89 B=n235 Y=n257
XU164 NAND2X1TR $PINS A=n91 B=n90 Y=n148
XU165 OAI21X1TR $PINS A0=n99 A1=n98 B0=n96 Y=n97
XU166 OAI2BB1X1TR $PINS A0N=n99 A1N=n98 B0=n97 Y=n79
XU167 XOR2X1TR $PINS A=n214 B=n229 Y=n108
XU169 OAI21X1TR $PINS A0=n105 A1=n104 B0=n103 Y=n106
XU170 XNOR2X1TR $PINS A=n108 B=n107 Y=n112
XU171 AOI32X1TR $PINS A0=n211 A1=n219 A2=n217 B0=n110 B1=n109 Y=n111
XU172 XNOR2X1TR $PINS A=n112 B=n111 Y=n158
XU173 OAI32X1TR $PINS A0=n149 A1=B<0> A2=n13 B0=n113 B1=n149 Y=n170
XU174 AOI22X1TR $PINS A0=B<0> A1=n127 B0=A<7> B1=n196 Y=n115
XU175 AOI22X1TR $PINS A0=A<7> A1=n152 B0=B<1> B1=n127 Y=n129
XU176 NAND2X1TR $PINS A=A<5> B=A<6> Y=n114
XU177 OAI22X1TR $PINS A0=n134 A1=n115 B0=n129 B1=n136 Y=n184
XU178 AOI22X1TR $PINS A0=A<3> A1=n138 B0=n149 B1=B<5> Y=n116
XU179 AOI22X1TR $PINS A0=A<3> A1=n141 B0=B<6> B1=n149 Y=n120
XU180 OAI22X1TR $PINS A0=n200 A1=n116 B0=n13 B1=n120 Y=n172
XU181 CLKINVX2TR $PINS A=B<4> Y=n157
XU182 AOI22X1TR $PINS A0=A<3> A1=n157 B0=B<4> B1=n149 Y=n117
XU183 OAI22X1TR $PINS A0=n200 A1=n117 B0=n13 B1=n116 Y=n173
XU184 AOI22X1TR $PINS A0=A<3> A1=n128 B0=B<2> B1=n149 Y=n197
XU185 AOI22X1TR $PINS A0=A<3> A1=n125 B0=B<3> B1=n149 Y=n118
XU186 OAI22X1TR $PINS A0=n200 A1=n197 B0=n13 B1=n118 Y=n175
XU187 OAI22X1TR $PINS A0=n200 A1=n118 B0=n13 B1=n117 Y=n174
XU188 OAI22X1TR $PINS A0=n200 A1=n120 B0=n13 B1=n119 Y=n171
XU189 AOI31X1TR $PINS A0=A<3> A1=A<4> A2=n140 B0=n121 Y=n194
XU190 AOI22X1TR $PINS A0=A<5> A1=n125 B0=B<3> B1=n140 Y=n122
XU191 OAI22X1TR $PINS A0=n194 A1=n122 B0=n139 B1=n195 Y=n188
XU192 AOI22X1TR $PINS A0=A<5> A1=n128 B0=B<2> B1=n140 Y=n190
XU193 OAI22X1TR $PINS A0=n194 A1=n190 B0=n195 B1=n122 Y=n145
XU194 AOI22X1TR $PINS A0=A<7> A1=n125 B0=B<3> B1=n127 Y=n133
XU195 AOI22X1TR $PINS A0=A<7> A1=n157 B0=B<4> B1=n127 Y=n126
XU196 OAI22X1TR $PINS A0=n134 A1=n133 B0=n126 B1=n136 Y=n167
XU197 AOI22X1TR $PINS A0=A<7> A1=n128 B0=B<2> B1=n127 Y=n135
XU198 OAI22X1TR $PINS A0=n134 A1=n129 B0=n135 B1=n136 Y=n168
XU199 AOI22X1TR $PINS A0=B<7> A1=n160 B0=A<1> B1=n130 Y=n162
XU200 OAI21X1TR $PINS A0=B<6> A1=n132 B0=n131 Y=n178
XU201 OAI22X1TR $PINS A0=n135 A1=n134 B0=n133 B1=n136 Y=n183
XU202 NOR2X1TR $PINS A=n196 B=n136 Y=n156
XU203 AOI22X1TR $PINS A0=B<0> A1=n140 B0=A<5> B1=n196 Y=n137
XU204 AOI22X1TR $PINS A0=A<5> A1=n152 B0=B<1> B1=n140 Y=n191
XU205 OAI22X1TR $PINS A0=n194 A1=n137 B0=n191 B1=n195 Y=n185
XU206 OAI22X1TR $PINS A0=n194 A1=n139 B0=n144 B1=n195 Y=n186
XU207 AOI22X1TR $PINS A0=A<5> A1=n141 B0=B<6> B1=n140 Y=n143
XU208 OAI22X1TR $PINS A0=n194 A1=n144 B0=n143 B1=n195 Y=n187
XU209 AOI22X1TR $PINS A0=A<3> A1=n196 B0=B<0> B1=n149 Y=n153
XU210 AOI22X1TR $PINS A0=A<3> A1=n152 B0=B<1> B1=n149 Y=n199
XU211 OAI22X1TR $PINS A0=n200 A1=n153 B0=n13 B1=n199 Y=n177
XU212 AOI22X1TR $PINS A0=B<5> A1=n160 B0=n159 B1=n157 Y=n163
XU213 OAI21X1TR $PINS A0=B<5> A1=n189 B0=n163 Y=n180
XU214 OAI22X1TR $PINS A0=n194 A1=n191 B0=n190 B1=n195 Y=n146
XU215 NOR2X1TR $PINS A=n196 B=n195 Y=n155
XU216 OAI22X1TR $PINS A0=n200 A1=n199 B0=n13 B1=n197 Y=n176
Xclk_r_REG427_S2 DFFQX1TR $PINS D=n255 CK=clk Q=n254
XU119 INVX2TR $PINS A=n67 Y=n43
XU116 AND2X2TR $PINS A=n38 B=FE_DBTN0_n255 Y=data_out<1>
XU25 INVX1TR $PINS A=n102 Y=n104
.ENDS

.SUBCKT buffer_mult_0 reset A<7> A<6> A<5> A<4> A<3> A<2> A<1> A<0> wrb_data<7>
+ wrb_data<6> wrb_data<5> wrb_data<4> wrb_data<3> wrb_data<2> wrb_data<1>
+ wrb_data<0> wrb_addr<3> wrb_addr<2> wrb_addr<1> wrb_addr<0> wrb rdb_addr<3>
+ rdb_addr<2> rdb_addr<1> rdb_addr<0> data_out<7> data_out<6> data_out<5>
+ data_out<4> data_out<3> data_out<2> data_out<1> data_out<0> FE_OFN15_reset
+ FE_OFN11_reset FE_OFN20_pe_in_pk_rdb_addr__2 FE_OFN22_pe_in_pk_rdb_addr__1
+ FE_OFN24_pe_in_pk_rdb_addr__0 FE_OFN30_pe_in_pk_rdb_addr__0
+ FE_OFN34_pe_in_pk_wrb_addr__0 FE_OFN36_pe_in_pk_wrb_addr__1 clk_clone4
+ clk_clone3 clk_clone2 clk_clone1 clk
Xclk_r_REG309_S1 DFFQX1TR $PINS D=mult_A<4> CK=clk Q=n5
Xclk_r_REG299_S1 DFFQX1TR $PINS D=mult_A<2> CK=clk Q=n3
Xclk_r_REG261_S1 DFFQX1TR $PINS D=mult_A<0> CK=clk Q=n1
Xclk_r_REG300_S1 DFFQX1TR $PINS D=mult_A<3> CK=clk Q=n4
Xclk_r_REG288_S1 DFFQX1TR $PINS D=mult_A<1> CK=clk Q=n2
Xclk_r_REG317_S1 DFFQX1TR $PINS D=mult_A<6> CK=clk Q=n7
Xclk_r_REG310_S1 DFFQX1TR $PINS D=mult_A<5> CK=clk Q=n6
Xclk_r_REG318_S1 DFFQX1TR $PINS D=mult_A<7> CK=clk Q=n8
XU4 NOR2BX1TR $PINS AN=A<0> B=reset Y=mult_A<0>
XU5 NOR2BX1TR $PINS AN=A<1> B=reset Y=mult_A<1>
XU6 NOR2BX1TR $PINS AN=A<2> B=reset Y=mult_A<2>
XU7 NOR2BX1TR $PINS AN=A<3> B=reset Y=mult_A<3>
XU8 NOR2BX1TR $PINS AN=A<4> B=reset Y=mult_A<4>
XU9 NOR2BX1TR $PINS AN=A<5> B=reset Y=mult_A<5>
XU10 NOR2BX1TR $PINS AN=A<6> B=reset Y=mult_A<6>
XU11 NOR2BX1TR $PINS AN=A<7> B=reset Y=mult_A<7>
Xbuffer0 buffer_0 $PINS reset=FE_OFN15_reset wrb_data<7>=wrb_data<7>
+ wrb_data<6>=wrb_data<6> wrb_data<5>=wrb_data<5> wrb_data<4>=wrb_data<4>
+ wrb_data<3>=wrb_data<3> wrb_data<2>=wrb_data<2> wrb_data<1>=wrb_data<1>
+ wrb_data<0>=wrb_data<0> wrb_addr<3>=wrb_addr<3> wrb_addr<2>=wrb_addr<2>
+ wrb_addr<1>=wrb_addr<1> wrb_addr<0>=wrb_addr<0> wrb=wrb rdb_addr<3>=rdb_addr<3>
+ rdb_addr<2>=rdb_addr<2> rdb_addr<1>=rdb_addr<1> rdb_addr<0>=rdb_addr<0>
+ data_out<7>=buf_data<7> data_out<6>=buf_data<6> data_out<5>=buf_data<5>
+ data_out<4>=buf_data<4> data_out<3>=buf_data<3> data_out<2>=buf_data<2>
+ data_out<1>=buf_data<1> data_out<0>=buf_data<0>
+ FE_OFN21_pe_in_pk_rdb_addr__2=FE_OFN20_pe_in_pk_rdb_addr__2
+ FE_OFN23_pe_in_pk_rdb_addr__1=FE_OFN22_pe_in_pk_rdb_addr__1
+ FE_OFN25_pe_in_pk_rdb_addr__0=FE_OFN24_pe_in_pk_rdb_addr__0
+ FE_OFN31_pe_in_pk_rdb_addr__0=FE_OFN30_pe_in_pk_rdb_addr__0
+ FE_OFN35_pe_in_pk_wrb_addr__0=FE_OFN34_pe_in_pk_wrb_addr__0
+ FE_OFN37_pe_in_pk_wrb_addr__1=FE_OFN36_pe_in_pk_wrb_addr__1
+ clk_clone2=clk_clone3 clk_clone1=clk_clone2 clk=clk_clone1
XMULT_single0 MULT_single_0 $PINS reset=reset A<7>=n8 A<6>=n7 A<5>=n6 A<4>=n5
+ A<3>=n4 A<2>=n3 A<1>=n2 A<0>=n1 B<7>=buf_data<7> B<6>=buf_data<6>
+ B<5>=buf_data<5> B<4>=buf_data<4> B<3>=buf_data<3> B<2>=buf_data<2>
+ B<1>=buf_data<1> B<0>=buf_data<0> data_out<7>=data_out<7>
+ data_out<6>=data_out<6> data_out<5>=data_out<5> data_out<4>=data_out<4>
+ data_out<3>=data_out<3> data_out<2>=data_out<2> data_out<1>=data_out<1>
+ data_out<0>=data_out<0> clk_clone2=clk_clone4 clk_clone1=clk_clone3 clk=clk
.ENDS

.SUBCKT buff_mult_arr reset state_out<2> state_out<1> state_out<0>
+ data_out_3__7_ data_out_3__6_ data_out_3__5_ data_out_3__4_ data_out_3__3_
+ data_out_3__2_ data_out_3__1_ data_out_3__0_ data_out_2__7_ data_out_2__6_
+ data_out_2__5_ data_out_2__4_ data_out_2__3_ data_out_2__2_ data_out_2__1_
+ data_out_2__0_ data_out_1__7_ data_out_1__6_ data_out_1__5_ data_out_1__4_
+ data_out_1__3_ data_out_1__2_ data_out_1__1_ data_out_1__0_ data_out_0__7_
+ data_out_0__6_ data_out_0__5_ data_out_0__4_ data_out_0__3_ data_out_0__2_
+ data_out_0__1_ data_out_0__0_ pe_in_pk_PE_state__2_ pe_in_pk_PE_state__1_
+ pe_in_pk_PE_state__0_ pe_in_pk_A__3__7_ pe_in_pk_A__3__6_ pe_in_pk_A__3__5_
+ pe_in_pk_A__3__4_ pe_in_pk_A__3__3_ pe_in_pk_A__3__2_ pe_in_pk_A__3__1_
+ pe_in_pk_A__3__0_ pe_in_pk_A__2__7_ pe_in_pk_A__2__6_ pe_in_pk_A__2__5_
+ pe_in_pk_A__2__4_ pe_in_pk_A__2__3_ pe_in_pk_A__2__2_ pe_in_pk_A__2__1_
+ pe_in_pk_A__2__0_ pe_in_pk_A__1__7_ pe_in_pk_A__1__6_ pe_in_pk_A__1__5_
+ pe_in_pk_A__1__4_ pe_in_pk_A__1__3_ pe_in_pk_A__1__2_ pe_in_pk_A__1__1_
+ pe_in_pk_A__1__0_ pe_in_pk_A__0__7_ pe_in_pk_A__0__6_ pe_in_pk_A__0__5_
+ pe_in_pk_A__0__4_ pe_in_pk_A__0__3_ pe_in_pk_A__0__2_ pe_in_pk_A__0__1_
+ pe_in_pk_A__0__0_ pe_in_pk_wrb_data__7_ pe_in_pk_wrb_data__6_
+ pe_in_pk_wrb_data__5_ pe_in_pk_wrb_data__4_ pe_in_pk_wrb_data__3_
+ pe_in_pk_wrb_data__2_ pe_in_pk_wrb_data__1_ pe_in_pk_wrb_data__0_
+ pe_in_pk_wrb_addr__3_ pe_in_pk_wrb_addr__2_ pe_in_pk_wrb_addr__1_
+ pe_in_pk_wrb_addr__0_ pe_in_pk_wrb__3_ pe_in_pk_wrb__2_ pe_in_pk_wrb__1_
+ pe_in_pk_wrb__0_ pe_in_pk_rdb_addr__3_ pe_in_pk_rdb_addr__2_
+ pe_in_pk_rdb_addr__1_ pe_in_pk_rdb_addr__0_ FE_OFN0_reset FE_OFN26_reset
+ clk_clone5 clk_clone4 clk_clone3 clk_clone2 clk_clone1 clk
XCTS_ccl_a_inv_00011 CLKINVX20TR $PINS A=CTS_7 Y=CTS_6
XCTS_ccl_a_inv_00009 CLKINVX20TR $PINS A=CTS_7 Y=CTS_5
XCTS_ccl_a_inv_00008 CLKINVX20TR $PINS A=CTS_7 Y=CTS_4
XCTS_ccl_a_inv_00015 CLKINVX20TR $PINS A=clk Y=CTS_7
XCTS_ccl_a_inv_00010 CLKINVX20TR $PINS A=clk_clone1 Y=CTS_3
XCTS_ccl_a_inv_00004 CLKINVX20TR $PINS A=clk_clone1 Y=CTS_2
XCTS_ccl_a_inv_00007 CLKINVX20TR $PINS A=clk_clone4 Y=CTS_1
XCTS_ccl_a_inv_00006 CLKINVX20TR $PINS A=clk_clone4 Y=CTS_9
XCTS_ccl_a_inv_00005 CLKINVX20TR $PINS A=clk_clone4 Y=CTS_8
XPLACEDFE_OFC109_pe_in_pk_wrb_addr__1 BUFX3TR $PINS
+ A=FE_OFN8_pe_in_pk_wrb_addr__1 Y=FE_OFN57_pe_in_pk_wrb_addr__1
XPLACEDFE_OFC108_pe_in_pk_wrb_addr__1 BUFX3TR $PINS A=pe_in_pk_wrb_addr__1_
+ Y=FE_OFN8_pe_in_pk_wrb_addr__1
XPLACEDFE_OFC102_pe_in_pk_wrb_addr__0 BUFX3TR $PINS A=pe_in_pk_wrb_addr__0_
+ Y=FE_OFN9_pe_in_pk_wrb_addr__0
XPLACEDFE_OFC82_pe_in_pk_wrb_addr__2 CLKBUFX2TR $PINS A=pe_in_pk_wrb_addr__2_
+ Y=FE_OFN7_pe_in_pk_wrb_addr__2
XPLACEDFE_OFC69_pe_in_pk_rdb_addr__0 INVX12TR $PINS
+ A=FE_OFN12_pe_in_pk_rdb_addr__0 Y=FE_OFN50_pe_in_pk_rdb_addr__0
XPLACEDFE_OFC68_pe_in_pk_rdb_addr__0 INVX2TR $PINS A=pe_in_pk_rdb_addr__0_
+ Y=FE_OFN12_pe_in_pk_rdb_addr__0
XPLACEDFE_OFC60_reset BUFX8TR $PINS A=FE_OFN6_reset Y=FE_OFN48_reset
XPLACEDFE_OFC59_reset CLKBUFX2TR $PINS A=FE_OFN5_reset Y=FE_OFN47_reset
XPLACEDFE_OFC58_reset CLKINVX2TR $PINS A=FE_OFN4_reset Y=FE_OFN46_reset
XPLACEDFE_OFC57_reset CLKINVX6TR $PINS A=FE_OFN4_reset Y=FE_OFN6_reset
XPLACEDFE_OFC55_reset CLKBUFX2TR $PINS A=FE_OFN3_reset Y=FE_OFN5_reset
XPLACEDFE_OFC54_reset INVX2TR $PINS A=FE_OFN0_reset Y=FE_OFN4_reset
XPLACEDFE_OFC51_reset CLKBUFX2TR $PINS A=FE_OFN0_reset Y=FE_OFN3_reset
XPLACEDFE_OFC45_pe_in_pk_rdb_addr__1 BUFX16TR $PINS A=pe_in_pk_rdb_addr__1_
+ Y=FE_OFN11_pe_in_pk_rdb_addr__1
Xclk_r_REG83_S1 DFFQX1TR $PINS D=state_int1<2> CK=CTS_8 Q=n10
Xclk_r_REG82_S1 DFFQX1TR $PINS D=state_int1<1> CK=CTS_8 Q=n9
Xclk_r_REG81_S1 DFFQX1TR $PINS D=state_int1<0> CK=CTS_8 Q=n8
Xclk_r_REG80_S1 DFFQX1TR $PINS D=state_int2<2> CK=CTS_8 Q=n7
Xclk_r_REG79_S1 DFFQX1TR $PINS D=state_int2<1> CK=CTS_8 Q=n6
Xclk_r_REG78_S1 DFFQX1TR $PINS D=state_int2<0> CK=CTS_8 Q=n5
Xclk_r_REG77_S1 DFFQX1TR $PINS D=n13 CK=clk_clone2 Q=state_out<2>
Xclk_r_REG76_S1 DFFQX1TR $PINS D=n14 CK=clk_clone2 Q=state_out<1>
Xclk_r_REG75_S1 DFFQX1TR $PINS D=n15 CK=clk_clone2 Q=state_out<0>
XU6 NOR2BX1TR $PINS AN=n5 B=FE_OFN0_reset Y=n15
XU7 NOR2BX1TR $PINS AN=n6 B=FE_OFN5_reset Y=n14
XU8 NOR2BX1TR $PINS AN=n7 B=FE_OFN0_reset Y=n13
XU9 NOR2BX1TR $PINS AN=n8 B=FE_OFN47_reset Y=state_int2<0>
XU10 NOR2BX1TR $PINS AN=n9 B=FE_OFN47_reset Y=state_int2<1>
XU11 NOR2BX1TR $PINS AN=n10 B=FE_OFN47_reset Y=state_int2<2>
XU12 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__0_ B=FE_OFN47_reset Y=state_int1<0>
XU13 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__1_ B=FE_OFN47_reset Y=state_int1<1>
XU14 NOR2BX1TR $PINS AN=pe_in_pk_PE_state__2_ B=FE_OFN47_reset Y=state_int1<2>
Xgenblk1_0__buffer_mult0 buffer_mult_3 $PINS reset=reset A<7>=pe_in_pk_A__0__7_
+ A<6>=pe_in_pk_A__0__6_ A<5>=pe_in_pk_A__0__5_ A<4>=pe_in_pk_A__0__4_
+ A<3>=pe_in_pk_A__0__3_ A<2>=pe_in_pk_A__0__2_ A<1>=pe_in_pk_A__0__1_
+ A<0>=pe_in_pk_A__0__0_ wrb_data<7>=pe_in_pk_wrb_data__7_
+ wrb_data<6>=pe_in_pk_wrb_data__6_ wrb_data<5>=pe_in_pk_wrb_data__5_
+ wrb_data<4>=pe_in_pk_wrb_data__4_ wrb_data<3>=pe_in_pk_wrb_data__3_
+ wrb_data<2>=pe_in_pk_wrb_data__2_ wrb_data<1>=pe_in_pk_wrb_data__1_
+ wrb_data<0>=pe_in_pk_wrb_data__0_ wrb_addr<3>=pe_in_pk_wrb_addr__3_
+ wrb_addr<2>=FE_OFN7_pe_in_pk_wrb_addr__2
+ wrb_addr<1>=FE_OFN57_pe_in_pk_wrb_addr__1
+ wrb_addr<0>=FE_OFN9_pe_in_pk_wrb_addr__0 wrb=pe_in_pk_wrb__0_
+ rdb_addr<3>=pe_in_pk_rdb_addr__3_ rdb_addr<2>=pe_in_pk_rdb_addr__2_
+ rdb_addr<1>=FE_OFN11_pe_in_pk_rdb_addr__1
+ rdb_addr<0>=FE_OFN50_pe_in_pk_rdb_addr__0 data_out<7>=data_out_0__7_
+ data_out<6>=data_out_0__6_ data_out<5>=data_out_0__5_
+ data_out<4>=data_out_0__4_ data_out<3>=data_out_0__3_
+ data_out<2>=data_out_0__2_ data_out<1>=data_out_0__1_
+ data_out<0>=data_out_0__0_ FE_OFN6_reset=FE_OFN26_reset
+ FE_OFN3_reset=FE_OFN3_reset FE_OFN1_reset=FE_OFN0_reset
+ FE_OFN28_reset=FE_OFN46_reset FE_OFN27_reset=FE_OFN6_reset
+ clk_clone5=clk_clone3 clk_clone4=clk_clone2 clk_clone3=CTS_3 clk_clone2=CTS_5
+ clk_clone1=CTS_6 clk=CTS_7
Xgenblk1_1__buffer_mult0 buffer_mult_2 $PINS reset=FE_OFN6_reset
+ A<7>=pe_in_pk_A__1__7_ A<6>=pe_in_pk_A__1__6_ A<5>=pe_in_pk_A__1__5_
+ A<4>=pe_in_pk_A__1__4_ A<3>=pe_in_pk_A__1__3_ A<2>=pe_in_pk_A__1__2_
+ A<1>=pe_in_pk_A__1__1_ A<0>=pe_in_pk_A__1__0_ wrb_data<7>=pe_in_pk_wrb_data__7_
+ wrb_data<6>=pe_in_pk_wrb_data__6_ wrb_data<5>=pe_in_pk_wrb_data__5_
+ wrb_data<4>=pe_in_pk_wrb_data__4_ wrb_data<3>=pe_in_pk_wrb_data__3_
+ wrb_data<2>=pe_in_pk_wrb_data__2_ wrb_data<1>=pe_in_pk_wrb_data__1_
+ wrb_data<0>=pe_in_pk_wrb_data__0_ wrb_addr<3>=pe_in_pk_wrb_addr__3_
+ wrb_addr<2>=pe_in_pk_wrb_addr__2_ wrb_addr<1>=FE_OFN8_pe_in_pk_wrb_addr__1
+ wrb_addr<0>=FE_OFN9_pe_in_pk_wrb_addr__0 wrb=pe_in_pk_wrb__1_
+ rdb_addr<3>=pe_in_pk_rdb_addr__3_ rdb_addr<2>=pe_in_pk_rdb_addr__2_
+ rdb_addr<1>=FE_OFN11_pe_in_pk_rdb_addr__1
+ rdb_addr<0>=FE_OFN50_pe_in_pk_rdb_addr__0 data_out<7>=data_out_1__7_
+ data_out<6>=data_out_1__6_ data_out<5>=data_out_1__5_
+ data_out<4>=data_out_1__4_ data_out<3>=data_out_1__3_
+ data_out<2>=data_out_1__2_ data_out<1>=data_out_1__1_
+ data_out<0>=data_out_1__0_ FE_OFN8_reset=FE_OFN0_reset
+ FE_OFN4_reset=FE_OFN3_reset FE_OFN2_reset=FE_OFN46_reset
+ FE_OFN32_pe_in_pk_wrb_addr__2=FE_OFN7_pe_in_pk_wrb_addr__2
+ FE_OFN38_pe_in_pk_wrb_addr__1=FE_OFN57_pe_in_pk_wrb_addr__1
+ clk_clone5=clk_clone5 clk_clone4=clk_clone2 clk_clone3=CTS_2 clk_clone2=CTS_3
+ clk_clone1=CTS_4 clk=CTS_6
Xgenblk1_2__buffer_mult0 buffer_mult_1 $PINS reset=FE_OFN0_reset
+ A<7>=pe_in_pk_A__2__7_ A<6>=pe_in_pk_A__2__6_ A<5>=pe_in_pk_A__2__5_
+ A<4>=pe_in_pk_A__2__4_ A<3>=pe_in_pk_A__2__3_ A<2>=pe_in_pk_A__2__2_
+ A<1>=pe_in_pk_A__2__1_ A<0>=pe_in_pk_A__2__0_ wrb_data<7>=pe_in_pk_wrb_data__7_
+ wrb_data<6>=pe_in_pk_wrb_data__6_ wrb_data<5>=pe_in_pk_wrb_data__5_
+ wrb_data<4>=pe_in_pk_wrb_data__4_ wrb_data<3>=pe_in_pk_wrb_data__3_
+ wrb_data<2>=pe_in_pk_wrb_data__2_ wrb_data<1>=pe_in_pk_wrb_data__1_
+ wrb_data<0>=pe_in_pk_wrb_data__0_ wrb_addr<3>=pe_in_pk_wrb_addr__3_
+ wrb_addr<2>=pe_in_pk_wrb_addr__2_ wrb_addr<1>=pe_in_pk_wrb_addr__1_
+ wrb_addr<0>=FE_OFN9_pe_in_pk_wrb_addr__0 wrb=pe_in_pk_wrb__2_
+ rdb_addr<3>=pe_in_pk_rdb_addr__3_ rdb_addr<2>=pe_in_pk_rdb_addr__2_
+ rdb_addr<1>=FE_OFN11_pe_in_pk_rdb_addr__1
+ rdb_addr<0>=FE_OFN50_pe_in_pk_rdb_addr__0 data_out<7>=data_out_2__7_
+ data_out<6>=data_out_2__6_ data_out<5>=data_out_2__5_
+ data_out<4>=data_out_2__4_ data_out<3>=data_out_2__3_
+ data_out<2>=data_out_2__2_ data_out<1>=data_out_2__1_
+ data_out<0>=data_out_2__0_ FE_OFN13_reset=FE_OFN48_reset
+ FE_OFN12_reset=FE_OFN5_reset FE_OFN10_reset=FE_OFN6_reset
+ FE_OFN5_reset=FE_OFN3_reset
+ FE_OFN16_pe_in_pk_wrb_addr__1=FE_OFN8_pe_in_pk_wrb_addr__1
+ FE_OFN18_pe_in_pk_wrb_addr__0=FE_OFN9_pe_in_pk_wrb_addr__0
+ clk_clone6=clk_clone5 clk_clone5=CTS_8 clk_clone4=CTS_9 clk_clone3=CTS_1
+ clk_clone2=CTS_2 clk_clone1=CTS_4 clk=CTS_5
Xgenblk1_3__buffer_mult0 buffer_mult_0 $PINS reset=FE_OFN5_reset
+ A<7>=pe_in_pk_A__3__7_ A<6>=pe_in_pk_A__3__6_ A<5>=pe_in_pk_A__3__5_
+ A<4>=pe_in_pk_A__3__4_ A<3>=pe_in_pk_A__3__3_ A<2>=pe_in_pk_A__3__2_
+ A<1>=pe_in_pk_A__3__1_ A<0>=pe_in_pk_A__3__0_ wrb_data<7>=pe_in_pk_wrb_data__7_
+ wrb_data<6>=pe_in_pk_wrb_data__6_ wrb_data<5>=pe_in_pk_wrb_data__5_
+ wrb_data<4>=pe_in_pk_wrb_data__4_ wrb_data<3>=pe_in_pk_wrb_data__3_
+ wrb_data<2>=pe_in_pk_wrb_data__2_ wrb_data<1>=pe_in_pk_wrb_data__1_
+ wrb_data<0>=pe_in_pk_wrb_data__0_ wrb_addr<3>=pe_in_pk_wrb_addr__3_
+ wrb_addr<2>=pe_in_pk_wrb_addr__2_ wrb_addr<1>=pe_in_pk_wrb_addr__1_
+ wrb_addr<0>=pe_in_pk_wrb_addr__0_ wrb=pe_in_pk_wrb__3_
+ rdb_addr<3>=pe_in_pk_rdb_addr__3_ rdb_addr<2>=pe_in_pk_rdb_addr__2_
+ rdb_addr<1>=pe_in_pk_rdb_addr__1_ rdb_addr<0>=pe_in_pk_rdb_addr__0_
+ data_out<7>=data_out_3__7_ data_out<6>=data_out_3__6_
+ data_out<5>=data_out_3__5_ data_out<4>=data_out_3__4_
+ data_out<3>=data_out_3__3_ data_out<2>=data_out_3__2_
+ data_out<1>=data_out_3__1_ data_out<0>=data_out_3__0_
+ FE_OFN15_reset=FE_OFN48_reset FE_OFN11_reset=FE_OFN5_reset
+ FE_OFN20_pe_in_pk_rdb_addr__2=pe_in_pk_rdb_addr__2_
+ FE_OFN22_pe_in_pk_rdb_addr__1=FE_OFN11_pe_in_pk_rdb_addr__1
+ FE_OFN24_pe_in_pk_rdb_addr__0=FE_OFN12_pe_in_pk_rdb_addr__0
+ FE_OFN30_pe_in_pk_rdb_addr__0=FE_OFN50_pe_in_pk_rdb_addr__0
+ FE_OFN34_pe_in_pk_wrb_addr__0=FE_OFN9_pe_in_pk_wrb_addr__0
+ FE_OFN36_pe_in_pk_wrb_addr__1=FE_OFN8_pe_in_pk_wrb_addr__1
+ clk_clone4=clk_clone5 clk_clone3=CTS_8 clk_clone2=CTS_9 clk_clone1=CTS_1
+ clk=CTS_2
.ENDS

.SUBCKT adder reset status_in<2> status_in<1> status_in<0> data_in_3__7_
+ data_in_3__6_ data_in_3__5_ data_in_3__4_ data_in_3__3_ data_in_3__2_
+ data_in_3__1_ data_in_3__0_ data_in_2__7_ data_in_2__6_ data_in_2__5_
+ data_in_2__4_ data_in_2__3_ data_in_2__2_ data_in_2__1_ data_in_2__0_
+ data_in_1__7_ data_in_1__6_ data_in_1__5_ data_in_1__4_ data_in_1__3_
+ data_in_1__2_ data_in_1__1_ data_in_1__0_ data_in_0__7_ data_in_0__6_
+ data_in_0__5_ data_in_0__4_ data_in_0__3_ data_in_0__2_ data_in_0__1_
+ data_in_0__0_ status_out<2> status_out<1> status_out<0> data_out<7>
+ data_out<6> data_out<5> data_out<4> data_out<3> data_out<2> data_out<1>
+ data_out<0> clk_clone2 clk_clone1 clk
Xclk_r_REG71_S1 DFFQX1TR $PINS D=n93 CK=clk_clone1 Q=n92
Xclk_r_REG69_S1 DFFQX1TR $PINS D=n96 CK=clk_clone1 Q=status_out<0>
Xclk_r_REG49_S1 DFFQX1TR $PINS D=n94 CK=clk_clone1 Q=status_out<2>
Xclk_r_REG67_S1 DFFQX1TR $PINS D=n95 CK=clk_clone1 Q=status_out<1>
XDP_OP_12J1_122_5326_clk_r_REG88_S4 DFFQX4TR $PINS D=DP_OP_12J1_122_5326_n24
+ CK=clk Q=n76
XDP_OP_12J1_122_5326_clk_r_REG93_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n14
+ CK=clk Q=n75
XDP_OP_12J1_122_5326_clk_r_REG87_S4 DFFQX4TR $PINS D=DP_OP_12J1_122_5326_n26
+ CK=clk Q=n82
XDP_OP_12J1_122_5326_clk_r_REG91_S4 DFFQX1TR $PINS D=n73 CK=clk Q=n81
XDP_OP_12J1_122_5326_clk_r_REG89_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n25
+ CK=clk Q=n80
XDP_OP_12J1_122_5326_clk_r_REG90_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n22
+ CK=clk Q=n77
Xclk_r_REG74_S1 DFFHQX4TR $PINS D=n97 CK=clk_clone1 Q=data_out<2>
Xclk_r_REG72_S1 DFFQX1TR $PINS D=n99 CK=clk_clone1 Q=data_out<0>
XDP_OP_12J1_122_5326_clk_r_REG95_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n17
+ CK=clk Q=n78
XDP_OP_12J1_122_5326_clk_r_REG264_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n43
+ CK=clk_clone2 Q=n84
XDP_OP_12J1_122_5326_clk_r_REG94_S4 DFFQX1TR $PINS D=n85 CK=clk Q=n74
XDP_OP_12J1_122_5326_clk_r_REG92_S4 DFFQX4TR $PINS D=DP_OP_12J1_122_5326_n42
+ CK=clk Q=n83
XDP_OP_12J1_122_5326_clk_r_REG96_S4 DFFQX1TR $PINS D=DP_OP_12J1_122_5326_n16
+ CK=clk Q=n79
Xclk_r_REG73_S1 DFFQX1TR $PINS D=n98 CK=clk_clone1 Q=data_out<1>
XU3 AOI21X1TR $PINS A0=n33 A1=n34 B0=n29 Y=DP_OP_12J1_122_5326_n26
XU4 NAND2X4TR $PINS A=n28 B=n27 Y=n32
XU5 AND2X4TR $PINS A=data_in_3__0_ B=data_in_0__0_ Y=n19
XU6 AND2X2TR $PINS A=n65 B=n92 Y=data_out<5>
XU7 XNOR2X1TR $PINS A=n53 B=data_in_2__0_ Y=n54
XU8 INVX1TR $PINS A=reset Y=n93
XU9 NAND2X1TR $PINS A=n15 B=n14 Y=n24
XU10 OR2X2TR $PINS A=n42 B=n41 Y=n73
XU11 NAND2BX2TR $PINS AN=n4 B=n49 Y=n3
XU12 NOR2X2TR $PINS A=n15 B=n14 Y=n26
XU13 NOR2X1TR $PINS A=n31 B=n30 Y=DP_OP_12J1_122_5326_n24
XU14 XOR2X1TR $PINS A=n10 B=data_in_0__6_ Y=n36
XU15 OR2X4TR $PINS A=n37 B=n36 Y=n85
XU16 NOR2X1TR $PINS A=n48 B=n47 Y=DP_OP_12J1_122_5326_n16
XU17 OAI2BB1X1TR $PINS A0N=n45 A1N=data_in_2__4_ B0=n2 Y=n47
XU18 ADDFHX2TR $PINS A=data_in_2__3_ B=n21 CI=n20 S=n31 CO=n41
XU19 NAND2X1TR $PINS A=n62 B=n78 Y=n63
XU20 XOR2X1TR $PINS A=data_in_1__6_ B=data_in_3__6_ Y=n10
XU21 OAI2BB1X1TR $PINS A0N=data_in_3__6_ A1N=data_in_0__6_ B0=n13 Y=n4
XU22 NAND2X1TR $PINS A=data_in_1__6_ B=data_in_3__6_ Y=n13
XU23 XNOR2X2TR $PINS A=n60 B=n59 Y=n61
XU24 XOR2X2TR $PINS A=n52 B=n12 Y=DP_OP_12J1_122_5326_n42
XU25 OAI22X1TR $PINS A0=n5 A1=n53 B0=data_in_1__0_ B1=data_in_2__0_ Y=n25
XU26 XOR2X1TR $PINS A=data_in_3__0_ B=data_in_0__0_ Y=n53
XU27 XOR2X4TR $PINS A=n3 B=data_in_2__7_ Y=n12
XU28 NAND2X1TR $PINS A=data_in_1__6_ B=data_in_0__6_ Y=n49
XU29 NAND2X1TR $PINS A=n31 B=n30 Y=DP_OP_12J1_122_5326_n25
XU30 AND2X1TR $PINS A=n55 B=n93 Y=n99
XU31 XNOR2X1TR $PINS A=data_in_1__0_ B=n54 Y=n55
XU32 XOR2X1TR $PINS A=n44 B=data_in_2__5_ Y=n11
XU33 XOR2X2TR $PINS A=n1 B=n46 Y=n42
XU34 XOR2X2TR $PINS A=n45 B=data_in_2__4_ Y=n1
XU35 OAI21X1TR $PINS A0=n45 A1=data_in_2__4_ B0=n46 Y=n2
XU36 XNOR2X4TR $PINS A=n6 B=n34 Y=n35
XU37 OAI21X2TR $PINS A0=n26 A1=n25 B0=n24 Y=n34
XU38 AND2X2TR $PINS A=data_in_1__0_ B=data_in_2__0_ Y=n5
XU39 NAND2X4TR $PINS A=n33 B=n32 Y=n6
XU40 NAND2X4TR $PINS A=n8 B=n7 Y=n33
XU41 INVX4TR $PINS A=n27 Y=n7
XU42 INVX2TR $PINS A=n28 Y=n8
XU43 OAI2BB1X4TR $PINS A0N=data_in_2__5_ A1N=n44 B0=n9 Y=n50
XU44 OAI21X4TR $PINS A0=n44 A1=data_in_2__5_ B0=n43 Y=n9
XU45 XOR2X2TR $PINS A=n11 B=n43 Y=n48
XU46 AND2X4TR $PINS A=n58 B=n92 Y=data_out<3>
XU47 ADDFHX4TR $PINS A=data_in_2__6_ B=n51 CI=n50 S=n37 CO=n52
XU48 ADDFHX2TR $PINS A=data_in_2__2_ B=data_in_1__2_ CI=data_in_3__2_ S=n28
+ CO=n20
XU49 INVX1TR $PINS A=n75 Y=n66
XU50 XOR2X4TR $PINS A=n71 B=n70 Y=n72
XU51 INVX2TR $PINS A=n26 Y=n16
XU52 NAND2X1TR $PINS A=n16 B=n24 Y=n17
XU53 XOR2X1TR $PINS A=n17 B=n25 Y=n18
XU54 AND2X2TR $PINS A=n18 B=n93 Y=n98
XU55 CMPR22X4TR $PINS A=n19 B=data_in_2__1_ S=n14 CO=n23
XU56 ADDFHX4TR $PINS A=data_in_0__1_ B=data_in_3__1_ CI=data_in_1__1_ S=n15
+ CO=n22
XU57 ADDFX2TR $PINS A=data_in_0__3_ B=data_in_3__3_ CI=data_in_1__3_ S=n30
+ CO=n46
XU58 ADDFHX4TR $PINS A=n23 B=n22 CI=data_in_0__2_ S=n27 CO=n21
XU59 INVX2TR $PINS A=n32 Y=n29
XU60 XOR3X2TR $PINS A=data_in_1__7_ B=data_in_3__7_ C=data_in_0__7_
+ Y=DP_OP_12J1_122_5326_n43
XU61 ADDFHX4TR $PINS A=data_in_1__4_ B=data_in_3__4_ CI=data_in_0__4_ S=n45
+ CO=n44
XU62 ADDFHX4TR $PINS A=data_in_1__5_ B=data_in_3__5_ CI=data_in_0__5_ S=n43
+ CO=n51
XU63 CLKAND2X3TR $PINS A=n35 B=n93 Y=n97
XU64 NAND2X1TR $PINS A=n37 B=n36 Y=DP_OP_12J1_122_5326_n14
XU65 OAI21X2TR $PINS A0=n76 A1=n82 B0=n80 Y=n60
XU66 CLKINVX2TR $PINS A=n77 Y=n38
XU67 AOI21X2TR $PINS A0=n60 A1=n81 B0=n38 Y=n64
XU68 OAI21X4TR $PINS A0=n64 A1=n79 B0=n78 Y=n67
XU69 NAND2X1TR $PINS A=n74 B=n75 Y=n39
XU70 XNOR2X2TR $PINS A=n67 B=n39 Y=n40
XU71 AND2X4TR $PINS A=n40 B=n92 Y=data_out<6>
XU72 NAND2X1TR $PINS A=n42 B=n41 Y=DP_OP_12J1_122_5326_n22
XU73 NAND2X1TR $PINS A=n48 B=n47 Y=DP_OP_12J1_122_5326_n17
XU74 INVX2TR $PINS A=n76 Y=n56
XU75 NAND2X1TR $PINS A=n56 B=n80 Y=n57
XU76 XOR2X4TR $PINS A=n57 B=n82 Y=n58
XU77 NAND2X1TR $PINS A=n81 B=n77 Y=n59
XU78 AND2X2TR $PINS A=n61 B=n92 Y=data_out<4>
XU79 CLKINVX2TR $PINS A=n79 Y=n62
XU80 XOR2X2TR $PINS A=n64 B=n63 Y=n65
XU81 AOI21X1TR $PINS A0=n67 A1=n74 B0=n66 Y=n71
XU82 OR2X1TR $PINS A=n83 B=n84 Y=n69
XU83 NAND2X1TR $PINS A=n83 B=n84 Y=n68
XU84 NAND2X1TR $PINS A=n69 B=n68 Y=n70
XU85 AND2X4TR $PINS A=n72 B=n92 Y=data_out<7>
XU86 NOR2BX1TR $PINS AN=status_in<0> B=reset Y=n96
XU87 NOR2BX1TR $PINS AN=status_in<1> B=reset Y=n95
XU88 NOR2BX1TR $PINS AN=status_in<2> B=reset Y=n94
.ENDS

.SUBCKT accumulation reset status_in<2> status_in<1> status_in<0> data_new<7>
+ data_new<6> data_new<5> data_new<4> data_new<3> data_new<2> data_new<1>
+ data_new<0> data_out<7> data_out<6> data_out<5> data_out<4> data_out<3>
+ data_out<2> data_out<1> data_out<0> status_out<2> status_out<1> status_out<0>
+ clk
Xclk_r_REG56_S2 DFFQX1TR $PINS D=n64 CK=clk Q=n83
Xclk_r_REG64_S2 DFFQX1TR $PINS D=n62 CK=clk Q=n81
Xclk_r_REG58_S2 DFFQX1TR $PINS D=n60 CK=clk Q=n76
Xclk_r_REG51_S2 DFFQX1TR $PINS D=n57 CK=clk Q=n73
Xclk_r_REG66_S2 DFFQX1TR $PINS D=n58 CK=clk Q=n74
Xclk_r_REG50_S2 DFFQX1TR $PINS D=n92 CK=clk Q=status_out<2>
Xclk_r_REG68_S2 DFFQX1TR $PINS D=n93 CK=clk Q=status_out<1>
Xclk_r_REG70_S2 DFFQX1TR $PINS D=n94 CK=clk Q=status_out<0>
Xclk_r_REG55_S3 DFFQX1TR $PINS D=n84 CK=clk Q=data_out<7>
Xclk_r_REG57_S3 DFFQX1TR $PINS D=n85 CK=clk Q=data_out<6>
Xclk_r_REG59_S3 DFFQX1TR $PINS D=n86 CK=clk Q=data_out<5>
Xclk_r_REG61_S3 DFFQX1TR $PINS D=n87 CK=clk Q=data_out<4>
Xclk_r_REG63_S3 DFFQX1TR $PINS D=n88 CK=clk Q=data_out<3>
Xclk_r_REG53_S3 DFFQX1TR $PINS D=n89 CK=clk Q=data_out<2>
Xclk_r_REG65_S3 DFFQX1TR $PINS D=n90 CK=clk Q=data_out<1>
Xclk_r_REG52_S3 DFFQX1TR $PINS D=n91 CK=clk Q=data_out<0>
Xclk_r_REG60_S2 DFFQX1TR $PINS D=n63 CK=clk Q=n82
Xclk_r_REG62_S2 DFFQX1TR $PINS D=n59 CK=clk Q=n75
XU3 AO22X1TR $PINS A0=n13 A1=n51 B0=n54 B1=n74 Y=n58
XU4 AO22X1TR $PINS A0=n13 A1=n47 B0=n54 B1=n73 Y=n57
XU5 AND2X2TR $PINS A=n21 B=n49 Y=n88
XU7 OAI21X1TR $PINS A0=n15 A1=n34 B0=n35 Y=n20
XU8 AO22X1TR $PINS A0=n13 A1=n22 B0=n54 B1=n81 Y=n62
XU9 NAND2X4TR $PINS A=n9 B=n8 Y=n10
XU10 AND2X4TR $PINS A=n84 B=n53 Y=n14
XU11 AND2X2TR $PINS A=n86 B=n53 Y=n55
XU12 XNOR2X1TR $PINS A=n45 B=n44 Y=n46
XU13 NAND2X1TR $PINS A=n25 B=n24 Y=n26
XU14 AFHCINX2TR $PINS A=n74 B=data_new<1> CIN=n48 S=n50 CO=n38
XU15 AO22X1TR $PINS A0=n13 A1=n29 B0=n54 B1=n75 Y=n59
XU16 AO22X1TR $PINS A0=n13 A1=n52 B0=n54 B1=n80 Y=n61
XU17 INVX1TR $PINS A=n16 Y=n18
XU18 NOR2X2TR $PINS A=data_new<6> B=n76 Y=n30
XU19 AND2X1TR $PINS A=n40 B=n48 Y=n41
XU20 OR2X1TR $PINS A=data_new<0> B=n73 Y=n40
XU21 AND2X1TR $PINS A=n50 B=n49 Y=n90
XU22 AND2X2TR $PINS A=n39 B=n49 Y=n89
XU23 INVX1TR $PINS A=n34 Y=n36
XU24 AND2X2TR $PINS A=n28 B=n49 Y=n87
XU25 AND2X1TR $PINS A=status_in<0> B=n49 Y=n94
XU26 AND2X1TR $PINS A=status_in<1> B=n49 Y=n93
XU27 AND2X1TR $PINS A=status_in<2> B=n49 Y=n92
XU28 AND2X1TR $PINS A=n87 B=n53 Y=n29
XU29 AND2X2TR $PINS A=n85 B=n53 Y=n33
XU30 OAI21X4TR $PINS A0=n2 A1=n30 B0=n31 Y=n11
XU31 XOR2X2TR $PINS A=n4 B=n2 Y=n3
XU32 AOI21X4TR $PINS A0=n45 A1=n43 B0=n7 Y=n2
XU33 AND2X6TR $PINS A=n3 B=n49 Y=n85
XU34 NAND2X1TR $PINS A=n32 B=n31 Y=n4
XU35 NOR2X1TR $PINS A=data_new<2> B=n80 Y=n34
XU36 NOR2X2TR $PINS A=data_new<3> B=n81 Y=n16
XU37 NOR2X2TR $PINS A=n34 B=n16 Y=n6
XU38 NAND2X1TR $PINS A=data_new<0> B=n73 Y=n48
XU39 NAND2X1TR $PINS A=data_new<2> B=n80 Y=n35
XU40 NAND2X1TR $PINS A=data_new<3> B=n81 Y=n17
XU41 OAI21X2TR $PINS A0=n16 A1=n35 B0=n17 Y=n5
XU42 AOI21X2TR $PINS A0=n6 A1=n38 B0=n5 Y=n27
XU43 NOR2X1TR $PINS A=data_new<4> B=n75 Y=n23
XU44 NAND2X1TR $PINS A=data_new<4> B=n75 Y=n24
XU45 OAI21X2TR $PINS A0=n27 A1=n23 B0=n24 Y=n45
XU46 OR2X4TR $PINS A=data_new<5> B=n82 Y=n43
XU47 NAND2X1TR $PINS A=data_new<5> B=n82 Y=n42
XU48 INVX2TR $PINS A=n42 Y=n7
XU49 NAND2X1TR $PINS A=data_new<6> B=n76 Y=n31
XU50 OR2X2TR $PINS A=data_new<7> B=n83 Y=n9
XU51 NAND2X1TR $PINS A=data_new<7> B=n83 Y=n8
XU52 XNOR2X4TR $PINS A=n11 B=n10 Y=n12
XU54 AND2X6TR $PINS A=n12 B=n49 Y=n84
XU55 NOR2X1TR $PINS A=status_in<2> B=status_in<1> Y=n53
XU56 NAND3BX1TR $PINS AN=status_in<0> B=n49 C=n53 Y=n13
XU58 INVX2TR $PINS A=n13 Y=n54
XU59 AO22X4TR $PINS A0=n13 A1=n14 B0=n54 B1=n83 Y=n64
XU60 INVX1TR $PINS A=n38 Y=n15
XU61 NAND2X1TR $PINS A=n18 B=n17 Y=n19
XU62 XNOR2X1TR $PINS A=n20 B=n19 Y=n21
XU63 AND2X2TR $PINS A=n88 B=n53 Y=n22
XU64 INVX1TR $PINS A=n23 Y=n25
XU65 XOR2X1TR $PINS A=n27 B=n26 Y=n28
XU66 INVX2TR $PINS A=n30 Y=n32
XU67 AO22X4TR $PINS A0=n13 A1=n33 B0=n54 B1=n76 Y=n60
XU68 NAND2X1TR $PINS A=n36 B=n35 Y=n37
XU69 XNOR2X1TR $PINS A=n38 B=n37 Y=n39
XU70 NOR2BX1TR $PINS AN=n41 B=reset Y=n91
XU71 NAND2X1TR $PINS A=n43 B=n42 Y=n44
XU72 AND2X2TR $PINS A=n46 B=n49 Y=n86
XU73 AND2X2TR $PINS A=n91 B=n53 Y=n47
XU74 AND2X2TR $PINS A=n90 B=n53 Y=n51
XU75 AND2X2TR $PINS A=n89 B=n53 Y=n52
XU76 AO22X1TR $PINS A0=n13 A1=n55 B0=n54 B1=n82 Y=n63
Xclk_r_REG54_S2 DFFQX1TR $PINS D=n61 CK=clk Q=n80
XU6 INVX2TR $PINS A=reset Y=n49
.ENDS

.SUBCKT PE_top clk reset pe_in_pk_PE_state__2_ pe_in_pk_PE_state__1_
+ pe_in_pk_PE_state__0_ pe_in_pk_A__3__7_ pe_in_pk_A__3__6_ pe_in_pk_A__3__5_
+ pe_in_pk_A__3__4_ pe_in_pk_A__3__3_ pe_in_pk_A__3__2_ pe_in_pk_A__3__1_
+ pe_in_pk_A__3__0_ pe_in_pk_A__2__7_ pe_in_pk_A__2__6_ pe_in_pk_A__2__5_
+ pe_in_pk_A__2__4_ pe_in_pk_A__2__3_ pe_in_pk_A__2__2_ pe_in_pk_A__2__1_
+ pe_in_pk_A__2__0_ pe_in_pk_A__1__7_ pe_in_pk_A__1__6_ pe_in_pk_A__1__5_
+ pe_in_pk_A__1__4_ pe_in_pk_A__1__3_ pe_in_pk_A__1__2_ pe_in_pk_A__1__1_
+ pe_in_pk_A__1__0_ pe_in_pk_A__0__7_ pe_in_pk_A__0__6_ pe_in_pk_A__0__5_
+ pe_in_pk_A__0__4_ pe_in_pk_A__0__3_ pe_in_pk_A__0__2_ pe_in_pk_A__0__1_
+ pe_in_pk_A__0__0_ pe_in_pk_wrb_data__7_ pe_in_pk_wrb_data__6_
+ pe_in_pk_wrb_data__5_ pe_in_pk_wrb_data__4_ pe_in_pk_wrb_data__3_
+ pe_in_pk_wrb_data__2_ pe_in_pk_wrb_data__1_ pe_in_pk_wrb_data__0_
+ pe_in_pk_wrb_addr__3_ pe_in_pk_wrb_addr__2_ pe_in_pk_wrb_addr__1_
+ pe_in_pk_wrb_addr__0_ pe_in_pk_wrb__3_ pe_in_pk_wrb__2_ pe_in_pk_wrb__1_
+ pe_in_pk_wrb__0_ pe_in_pk_rdb_addr__3_ pe_in_pk_rdb_addr__2_
+ pe_in_pk_rdb_addr__1_ pe_in_pk_rdb_addr__0_ pe_out_pk_PE_state__2_
+ pe_out_pk_PE_state__1_ pe_out_pk_PE_state__0_ pe_out_pk_data__7_
+ pe_out_pk_data__6_ pe_out_pk_data__5_ pe_out_pk_data__4_ pe_out_pk_data__3_
+ pe_out_pk_data__2_ pe_out_pk_data__1_ pe_out_pk_data__0_
XCTS_ccl_a_inv_00002 CLKINVX20TR $PINS A=CTS_3 Y=CTS_5
XCTS_ccl_a_inv_00001 CLKINVX16TR $PINS A=CTS_3 Y=CTS_4
XCTS_ccl_a_inv_00014 CLKINVX20TR $PINS A=CTS_6 Y=CTS_3
XCTS_ccl_a_inv_00003 CLKINVX20TR $PINS A=CTS_2 Y=CTS_1
XCTS_ccl_a_inv_00013 CLKINVX20TR $PINS A=CTS_6 Y=CTS_2
XCTS_ccl_a_inv_00016 CLKINVX20TR $PINS A=CTS_7 Y=CTS_6
XCTS_ccl_a_inv_00017 CLKINVX8TR $PINS A=clk Y=CTS_7
XPLACEDFE_OFC52_reset CLKBUFX2TR $PINS A=FE_OFN1_reset Y=FE_OFN45_reset
XPLACEDFE_OFC50_reset BUFX16TR $PINS A=reset Y=FE_OFN1_reset
Xbuff_mult_arr0 buff_mult_arr $PINS reset=reset state_out<2>=ST_MULT<0>
+ state_out<1>=ST_MULT<1> state_out<0>=ST_MULT<2> data_out_3__7_=OUT_MULT<31>
+ data_out_3__6_=OUT_MULT<30> data_out_3__5_=OUT_MULT<29>
+ data_out_3__4_=OUT_MULT<28> data_out_3__3_=OUT_MULT<27>
+ data_out_3__2_=OUT_MULT<26> data_out_3__1_=OUT_MULT<25>
+ data_out_3__0_=OUT_MULT<24> data_out_2__7_=OUT_MULT<23>
+ data_out_2__6_=OUT_MULT<22> data_out_2__5_=OUT_MULT<21>
+ data_out_2__4_=OUT_MULT<20> data_out_2__3_=OUT_MULT<19>
+ data_out_2__2_=OUT_MULT<18> data_out_2__1_=OUT_MULT<17>
+ data_out_2__0_=OUT_MULT<16> data_out_1__7_=OUT_MULT<15>
+ data_out_1__6_=OUT_MULT<14> data_out_1__5_=OUT_MULT<13>
+ data_out_1__4_=OUT_MULT<12> data_out_1__3_=OUT_MULT<11>
+ data_out_1__2_=OUT_MULT<10> data_out_1__1_=OUT_MULT<9>
+ data_out_1__0_=OUT_MULT<8> data_out_0__7_=OUT_MULT<7>
+ data_out_0__6_=OUT_MULT<6> data_out_0__5_=OUT_MULT<5>
+ data_out_0__4_=OUT_MULT<4> data_out_0__3_=OUT_MULT<3>
+ data_out_0__2_=OUT_MULT<2> data_out_0__1_=OUT_MULT<1>
+ data_out_0__0_=OUT_MULT<0> pe_in_pk_PE_state__2_=pe_in_pk_PE_state__2_
+ pe_in_pk_PE_state__1_=pe_in_pk_PE_state__1_
+ pe_in_pk_PE_state__0_=pe_in_pk_PE_state__0_ pe_in_pk_A__3__7_=pe_in_pk_A__3__7_
+ pe_in_pk_A__3__6_=pe_in_pk_A__3__6_ pe_in_pk_A__3__5_=pe_in_pk_A__3__5_
+ pe_in_pk_A__3__4_=pe_in_pk_A__3__4_ pe_in_pk_A__3__3_=pe_in_pk_A__3__3_
+ pe_in_pk_A__3__2_=pe_in_pk_A__3__2_ pe_in_pk_A__3__1_=pe_in_pk_A__3__1_
+ pe_in_pk_A__3__0_=pe_in_pk_A__3__0_ pe_in_pk_A__2__7_=pe_in_pk_A__2__7_
+ pe_in_pk_A__2__6_=pe_in_pk_A__2__6_ pe_in_pk_A__2__5_=pe_in_pk_A__2__5_
+ pe_in_pk_A__2__4_=pe_in_pk_A__2__4_ pe_in_pk_A__2__3_=pe_in_pk_A__2__3_
+ pe_in_pk_A__2__2_=pe_in_pk_A__2__2_ pe_in_pk_A__2__1_=pe_in_pk_A__2__1_
+ pe_in_pk_A__2__0_=pe_in_pk_A__2__0_ pe_in_pk_A__1__7_=pe_in_pk_A__1__7_
+ pe_in_pk_A__1__6_=pe_in_pk_A__1__6_ pe_in_pk_A__1__5_=pe_in_pk_A__1__5_
+ pe_in_pk_A__1__4_=pe_in_pk_A__1__4_ pe_in_pk_A__1__3_=pe_in_pk_A__1__3_
+ pe_in_pk_A__1__2_=pe_in_pk_A__1__2_ pe_in_pk_A__1__1_=pe_in_pk_A__1__1_
+ pe_in_pk_A__1__0_=pe_in_pk_A__1__0_ pe_in_pk_A__0__7_=pe_in_pk_A__0__7_
+ pe_in_pk_A__0__6_=pe_in_pk_A__0__6_ pe_in_pk_A__0__5_=pe_in_pk_A__0__5_
+ pe_in_pk_A__0__4_=pe_in_pk_A__0__4_ pe_in_pk_A__0__3_=pe_in_pk_A__0__3_
+ pe_in_pk_A__0__2_=pe_in_pk_A__0__2_ pe_in_pk_A__0__1_=pe_in_pk_A__0__1_
+ pe_in_pk_A__0__0_=pe_in_pk_A__0__0_ pe_in_pk_wrb_data__7_=pe_in_pk_wrb_data__7_
+ pe_in_pk_wrb_data__6_=pe_in_pk_wrb_data__6_
+ pe_in_pk_wrb_data__5_=pe_in_pk_wrb_data__5_
+ pe_in_pk_wrb_data__4_=pe_in_pk_wrb_data__4_
+ pe_in_pk_wrb_data__3_=pe_in_pk_wrb_data__3_
+ pe_in_pk_wrb_data__2_=pe_in_pk_wrb_data__2_
+ pe_in_pk_wrb_data__1_=pe_in_pk_wrb_data__1_
+ pe_in_pk_wrb_data__0_=pe_in_pk_wrb_data__0_
+ pe_in_pk_wrb_addr__3_=pe_in_pk_wrb_addr__3_
+ pe_in_pk_wrb_addr__2_=pe_in_pk_wrb_addr__2_
+ pe_in_pk_wrb_addr__1_=pe_in_pk_wrb_addr__1_
+ pe_in_pk_wrb_addr__0_=pe_in_pk_wrb_addr__0_ pe_in_pk_wrb__3_=pe_in_pk_wrb__3_
+ pe_in_pk_wrb__2_=pe_in_pk_wrb__2_ pe_in_pk_wrb__1_=pe_in_pk_wrb__1_
+ pe_in_pk_wrb__0_=pe_in_pk_wrb__0_ pe_in_pk_rdb_addr__3_=pe_in_pk_rdb_addr__3_
+ pe_in_pk_rdb_addr__2_=pe_in_pk_rdb_addr__2_
+ pe_in_pk_rdb_addr__1_=pe_in_pk_rdb_addr__1_
+ pe_in_pk_rdb_addr__0_=pe_in_pk_rdb_addr__0_ FE_OFN0_reset=FE_OFN1_reset
+ FE_OFN26_reset=FE_OFN45_reset clk_clone5=CTS_1 clk_clone4=CTS_2
+ clk_clone3=CTS_4 clk_clone2=CTS_5 clk_clone1=CTS_3 clk=CTS_6
Xadder0 adder $PINS reset=FE_OFN45_reset status_in<2>=ST_MULT<0>
+ status_in<1>=ST_MULT<1> status_in<0>=ST_MULT<2> data_in_3__7_=OUT_MULT<31>
+ data_in_3__6_=OUT_MULT<30> data_in_3__5_=OUT_MULT<29>
+ data_in_3__4_=OUT_MULT<28> data_in_3__3_=OUT_MULT<27>
+ data_in_3__2_=OUT_MULT<26> data_in_3__1_=OUT_MULT<25>
+ data_in_3__0_=OUT_MULT<24> data_in_2__7_=OUT_MULT<23>
+ data_in_2__6_=OUT_MULT<22> data_in_2__5_=OUT_MULT<21>
+ data_in_2__4_=OUT_MULT<20> data_in_2__3_=OUT_MULT<19>
+ data_in_2__2_=OUT_MULT<18> data_in_2__1_=OUT_MULT<17>
+ data_in_2__0_=OUT_MULT<16> data_in_1__7_=OUT_MULT<15>
+ data_in_1__6_=OUT_MULT<14> data_in_1__5_=OUT_MULT<13>
+ data_in_1__4_=OUT_MULT<12> data_in_1__3_=OUT_MULT<11>
+ data_in_1__2_=OUT_MULT<10> data_in_1__1_=OUT_MULT<9> data_in_1__0_=OUT_MULT<8>
+ data_in_0__7_=OUT_MULT<7> data_in_0__6_=OUT_MULT<6> data_in_0__5_=OUT_MULT<5>
+ data_in_0__4_=OUT_MULT<4> data_in_0__3_=OUT_MULT<3> data_in_0__2_=OUT_MULT<2>
+ data_in_0__1_=OUT_MULT<1> data_in_0__0_=OUT_MULT<0> status_out<2>=ST_ADD<0>
+ status_out<1>=ST_ADD<1> status_out<0>=ST_ADD<2> data_out<7>=OUT_ADD<7>
+ data_out<6>=OUT_ADD<6> data_out<5>=OUT_ADD<5> data_out<4>=OUT_ADD<4>
+ data_out<3>=OUT_ADD<3> data_out<2>=OUT_ADD<2> data_out<1>=OUT_ADD<1>
+ data_out<0>=OUT_ADD<0> clk_clone2=CTS_1 clk_clone1=CTS_4 clk=CTS_5
Xaccumulation0 accumulation $PINS reset=FE_OFN45_reset status_in<2>=ST_ADD<0>
+ status_in<1>=ST_ADD<1> status_in<0>=ST_ADD<2> data_new<7>=OUT_ADD<7>
+ data_new<6>=OUT_ADD<6> data_new<5>=OUT_ADD<5> data_new<4>=OUT_ADD<4>
+ data_new<3>=OUT_ADD<3> data_new<2>=OUT_ADD<2> data_new<1>=OUT_ADD<1>
+ data_new<0>=OUT_ADD<0> data_out<7>=pe_out_pk_data__7_
+ data_out<6>=pe_out_pk_data__6_ data_out<5>=pe_out_pk_data__5_
+ data_out<4>=pe_out_pk_data__4_ data_out<3>=pe_out_pk_data__3_
+ data_out<2>=pe_out_pk_data__2_ data_out<1>=pe_out_pk_data__1_
+ data_out<0>=pe_out_pk_data__0_ status_out<2>=pe_out_pk_PE_state__2_
+ status_out<1>=pe_out_pk_PE_state__1_ status_out<0>=pe_out_pk_PE_state__0_
+ clk=CTS_4
.ENDS
