*
* Copyright 2022 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3e
* Version: 2008Q3V1
* Name: High Speed/Density Single Port SRAM Generator|IBM CMRF8SF-LPVT Process
* Comment:
* Configuration:  -instname "SIGN_MEM" -words 4096 -bits 16 -freque\
* Configuration: ncy 100 -ring_width 4.0 -mux 16 -write_mask off -w\
* Configuration: p_size 8 -top_layer met4 -power_type rings -horiz \
* Configuration: met4 -vert met3 -cust_comment "" -bus_notation on \
* Configuration: -left_bus_delim "[" -right_bus_delim "]" -pwr_gnd_\
* Configuration: rename "VDD:VDD,GND:VSS" -prefix "" -pin_space 0.0\
* Configuration:  -name_case upper -check_instname on -diodes on -i\
* Configuration: nside_ring_type GND -drive 6 -asvm on -corners ff_\
* Configuration: 1p32v_m40c,ff_1p65v_125c,tt_1p2v_25c,ss_1p08v_125c
* Codefile:
*
*
** begin lvs.header
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT SIGN_MEMFLCCSTRAPR NDL WL VDD VSS
** SIGN_MEMFLCCSTRAPR: 1 flat devices **
m1 VSS WL NDL VSS LPNFET L=0.13U W=0.16U
.ENDS SIGN_MEMFLCCSTRAPR
****
.SUBCKT SIGN_MEMFCIO8 GTP OE_ WE VDD VSS
** SIGN_MEMFCIO8: 3 flat devices **
d1 VSS OE_ tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS GTP tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS WE tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCIO8
****
.SUBCKT SIGN_MEMFCSA8 GTP VDD VSS
** SIGN_MEMFCSA8: 1 flat devices **
d1 VSS GTP tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCSA8
****
.SUBCKT SIGN_MEMLEFT_CAP A0 A0_ DR DR_ DW DW_ GTP_0 GTP_1 GTP_2 OE_ WE WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMLEFT_CAP: 262 flat devices **
XI0_0 GTP_0 OE_ WE VDD VSS SIGN_MEMFCIO8
XI0_1 GTP_1 VDD VSS SIGN_MEMFCSA8
XI0_10 NDL_183 WL_6 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_100 NDL_5 WL_96 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_101 NDL_5 WL_97 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_102 NDL_7 WL_98 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_103 NDL_7 WL_99 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_104 NDL_9 WL_100 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_105 NDL_9 WL_101 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_106 NDL_11 WL_102 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_107 NDL_11 WL_103 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_108 NDL_15 WL_104 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_109 NDL_15 WL_105 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_11 NDL_183 WL_7 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_110 NDL_37 WL_106 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_111 NDL_37 WL_107 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_112 NDL_39 WL_108 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_113 NDL_39 WL_109 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_114 NDL_41 WL_110 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_115 NDL_41 WL_111 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_116 NDL_43 WL_112 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_117 NDL_43 WL_113 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_118 NDL_45 WL_114 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_119 NDL_45 WL_115 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_12 NDL_185 WL_8 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_120 NDL_69 WL_116 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_121 NDL_69 WL_117 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_122 NDL_73 WL_118 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_123 NDL_73 WL_119 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_124 NDL_77 WL_120 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_125 NDL_77 WL_121 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_126 NDL_81 WL_122 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_127 NDL_81 WL_123 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_128 NDL_85 WL_124 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_129 NDL_85 WL_125 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_13 NDL_185 WL_9 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_130 NDL_101 WL_126 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_131 NDL_101 WL_127 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_132 NDL_107 WL_128 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_133 NDL_107 WL_129 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_134 NDL_113 WL_130 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_135 NDL_113 WL_131 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_136 NDL_117 WL_132 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_137 NDL_117 WL_133 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_138 NDL_121 WL_134 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_139 NDL_121 WL_135 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_14 NDL_187 WL_10 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_140 NDL_135 WL_136 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_141 NDL_135 WL_137 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_142 NDL_139 WL_138 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_143 NDL_139 WL_139 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_144 NDL_143 WL_140 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_145 NDL_143 WL_141 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_146 NDL_147 WL_142 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_147 NDL_147 WL_143 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_148 NDL_151 WL_144 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_149 NDL_151 WL_145 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_15 NDL_187 WL_11 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_150 NDL_165 WL_146 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_151 NDL_165 WL_147 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_152 NDL_169 WL_148 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_153 NDL_169 WL_149 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_154 NDL_173 WL_150 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_155 NDL_173 WL_151 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_156 NDL_177 WL_152 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_157 NDL_177 WL_153 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_158 NDL_181 WL_154 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_159 NDL_181 WL_155 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_16 NDL_189 WL_12 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_160 NDL_205 WL_156 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_161 NDL_205 WL_157 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_162 NDL_209 WL_158 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_163 NDL_209 WL_159 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_164 NDL_213 WL_160 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_165 NDL_213 WL_161 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_166 NDL_217 WL_162 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_167 NDL_217 WL_163 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_168 NDL_221 WL_164 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_169 NDL_221 WL_165 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_17 NDL_189 WL_13 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_170 NDL_235 WL_166 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_171 NDL_235 WL_167 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_172 NDL_239 WL_168 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_173 NDL_239 WL_169 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_174 NDL_243 WL_170 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_175 NDL_243 WL_171 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_176 NDL_247 WL_172 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_177 NDL_247 WL_173 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_178 NDL_251 WL_174 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_179 NDL_251 WL_175 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_18 NDL_191 WL_14 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_180 NDL_17 WL_176 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_181 NDL_17 WL_177 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_182 NDL_19 WL_178 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_183 NDL_19 WL_179 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_184 NDL_21 WL_180 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_185 NDL_21 WL_181 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_186 NDL_23 WL_182 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_187 NDL_23 WL_183 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_188 NDL_25 WL_184 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_189 NDL_25 WL_185 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_19 NDL_191 WL_15 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_190 NDL_47 WL_186 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_191 NDL_47 WL_187 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_192 NDL_49 WL_188 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_193 NDL_49 WL_189 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_194 NDL_51 WL_190 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_195 NDL_51 WL_191 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_196 NDL_53 WL_192 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_197 NDL_53 WL_193 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_198 NDL_55 WL_194 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_199 NDL_55 WL_195 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_20 NDL_223 WL_16 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_200 NDL_67 WL_196 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_201 NDL_67 WL_197 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_202 NDL_71 WL_198 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_203 NDL_71 WL_199 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_204 NDL_75 WL_200 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_205 NDL_75 WL_201 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_206 NDL_79 WL_202 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_207 NDL_79 WL_203 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_208 NDL_83 WL_204 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_209 NDL_83 WL_205 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_21 NDL_223 WL_17 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_210 NDL_97 WL_206 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_211 NDL_97 WL_207 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_212 NDL_103 WL_208 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_213 NDL_103 WL_209 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_214 NDL_109 WL_210 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_215 NDL_109 WL_211 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_216 NDL_115 WL_212 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_217 NDL_115 WL_213 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_218 NDL_119 WL_214 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_219 NDL_119 WL_215 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_22 NDL_225 WL_18 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_220 NDL_133 WL_216 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_221 NDL_133 WL_217 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_222 NDL_137 WL_218 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_223 NDL_137 WL_219 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_224 NDL_141 WL_220 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_225 NDL_141 WL_221 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_226 NDL_145 WL_222 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_227 NDL_145 WL_223 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_228 NDL_149 WL_224 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_229 NDL_149 WL_225 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_23 NDL_225 WL_19 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_230 NDL_163 WL_226 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_231 NDL_163 WL_227 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_232 NDL_167 WL_228 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_233 NDL_167 WL_229 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_234 NDL_171 WL_230 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_235 NDL_171 WL_231 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_236 NDL_175 WL_232 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_237 NDL_175 WL_233 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_238 NDL_179 WL_234 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_239 NDL_179 WL_235 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_24 NDL_227 WL_20 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_240 NDL_203 WL_236 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_241 NDL_203 WL_237 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_242 NDL_207 WL_238 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_243 NDL_207 WL_239 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_244 NDL_211 WL_240 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_245 NDL_211 WL_241 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_246 NDL_215 WL_242 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_247 NDL_215 WL_243 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_248 NDL_219 WL_244 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_249 NDL_219 WL_245 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_25 NDL_227 WL_21 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_250 NDL_233 WL_246 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_251 NDL_233 WL_247 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_252 NDL_237 WL_248 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_253 NDL_237 WL_249 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_254 NDL_241 WL_250 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_255 NDL_241 WL_251 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_256 NDL_245 WL_252 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_257 NDL_245 WL_253 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_258 NDL_249 WL_254 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_259 NDL_249 WL_255 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_26 NDL_229 WL_22 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_261 NDL_13 VSS VDD VSS SIGN_MEMFLCCSTRAPR
XI0_262 NDL_13 VSS VDD VSS SIGN_MEMFLCCSTRAPR
XI0_27 NDL_229 WL_23 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_28 NDL_231 WL_24 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_29 NDL_231 WL_25 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_30 NDL_253 WL_26 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_31 NDL_253 WL_27 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_32 NDL_255 WL_28 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_33 NDL_255 WL_29 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_34 NDL WL_30 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_35 NDL WL_31 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_36 NDL_1 WL_32 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_37 NDL_1 WL_33 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_38 NDL_3 WL_34 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_39 NDL_3 WL_35 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_4 NDL_99 WL_0 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_40 NDL_27 WL_36 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_41 NDL_27 WL_37 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_42 NDL_29 WL_38 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_43 NDL_29 WL_39 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_44 NDL_31 WL_40 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_45 NDL_31 WL_41 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_46 NDL_33 WL_42 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_47 NDL_33 WL_43 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_48 NDL_35 WL_44 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_49 NDL_35 WL_45 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_5 NDL_99 WL_1 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_50 NDL_57 WL_46 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_51 NDL_57 WL_47 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_52 NDL_59 WL_48 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_53 NDL_59 WL_49 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_54 NDL_61 WL_50 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_55 NDL_61 WL_51 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_56 NDL_63 WL_52 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_57 NDL_63 WL_53 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_58 NDL_65 WL_54 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_59 NDL_65 WL_55 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_6 NDL_105 WL_2 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_60 NDL_87 WL_56 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_61 NDL_87 WL_57 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_62 NDL_89 WL_58 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_63 NDL_89 WL_59 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_64 NDL_91 WL_60 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_65 NDL_91 WL_61 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_66 NDL_93 WL_62 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_67 NDL_93 WL_63 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_68 NDL_95 WL_64 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_69 NDL_95 WL_65 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_7 NDL_105 WL_3 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_70 NDL_123 WL_66 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_71 NDL_123 WL_67 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_72 NDL_125 WL_68 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_73 NDL_125 WL_69 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_74 NDL_127 WL_70 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_75 NDL_127 WL_71 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_76 NDL_129 WL_72 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_77 NDL_129 WL_73 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_78 NDL_131 WL_74 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_79 NDL_131 WL_75 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_8 NDL_111 WL_4 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_80 NDL_153 WL_76 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_81 NDL_153 WL_77 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_82 NDL_155 WL_78 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_83 NDL_155 WL_79 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_84 NDL_157 WL_80 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_85 NDL_157 WL_81 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_86 NDL_159 WL_82 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_87 NDL_159 WL_83 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_88 NDL_161 WL_84 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_89 NDL_161 WL_85 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_9 NDL_111 WL_5 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_90 NDL_193 WL_86 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_91 NDL_193 WL_87 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_92 NDL_195 WL_88 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_93 NDL_195 WL_89 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_94 NDL_197 WL_90 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_95 NDL_197 WL_91 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_96 NDL_199 WL_92 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_97 NDL_199 WL_93 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_98 NDL_201 WL_94 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_99 NDL_201 WL_95 VDD VSS SIGN_MEMFLCCSTRAPR
.ENDS SIGN_MEMLEFT_CAP
****
.SUBCKT SIGN_MEMFCBWLE16 BWEN D Q VDD VSS
** SIGN_MEMFCBWLE16: 3 flat devices **
d1 VSS Q tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS D tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCBWLE16
****
.SUBCKT SIGN_MEMFCBWLX BWEN D Q VDD VSS
** SIGN_MEMFCBWLX: 3 flat devices **
XI0_0 BWEN D Q VDD VSS SIGN_MEMFCBWLE16
.ENDS SIGN_MEMFCBWLX
****
.SUBCKT SIGN_MEMFLIO GTP OE_ WE VDD VSS
** SIGN_MEMFLIO: 3 flat devices **
d1 VSS GTP tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS OE_ tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS WE tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFLIO
****
.SUBCKT SIGN_MEMIO8 BWE BWEN D DPN DPU DW DW_ GTP OE_ Q SP STUBWE STUBWEI WE
+  VDD VSS
** SIGN_MEMIO8: 58 flat devices **
m1 QI DPU VSS VSS LPNFET L=0.12U W=1.9U
m10 QPD OEI_ VSS VSS LPNFET L=0.12U W=0.28U
m11 QIL QI VDD VDD LPPFET L=0.12U W=1U
m12 QIL QI VSS VSS LPNFET L=0.12U W=0.4U
m13 SPN SP VDD VDD LPPFET L=0.12U W=0.28U
m14 SPN SP VSS VSS LPNFET L=0.12U W=0.18U
m15 DWPD GTPND DWI VSS LPNFET L=0.12U W=0.72U
m16 DWPD DW VDD VDD LPPFET L=0.18U W=0.16U
m17 DWPD DW VSS VSS LPNFET L=0.66U W=0.16U
m18 DWPD GTP DWI VDD LPPFET L=0.12U W=0.86U
m19 DW_PU GTPND DNWI VSS LPNFET L=0.12U W=0.72U
m2 QI DPN VDD VDD LPPFET L=0.12U W=6U
m20 DW_PU GTP DNWI VDD LPPFET L=0.12U W=0.86U
m21 GTPND GTP VDD VDD LPPFET L=0.12U W=0.56U
m22 GTPND GTP VSS VSS LPNFET L=0.12U W=0.48U
m23 DI N48 VDD VDD LPPFET L=0.12U W=1.26U
m24 DI N48 VSS VSS LPNFET L=0.12U W=0.64U
m25 DNN DI VDD VDD LPPFET L=0.12U W=0.88U
m26 DNN DI VSS VSS LPNFET L=0.12U W=0.44U
m27 WEI N53 VDD VDD LPPFET L=0.12U W=1.02U
m28 WEI N53 VSS VSS LPNFET L=0.12U W=0.62U
m29 OEI OEI_ VDD VDD LPPFET L=0.12U W=0.78U
m3 Q QPU VDD VDD LPPFET L=0.12U W=7U
m30 OEI OEI_ VSS VSS LPNFET L=0.12U W=0.42U
m31 QI SP N79 VDD LPPFET L=0.12U W=1.08U
m32 N79 QIL VDD VDD LPPFET L=0.12U W=1.08U
m33 QI SPN N78 VSS LPNFET L=0.12U W=1.08U
m34 N78 QIL VSS VSS LPNFET L=0.12U W=1.08U
m35 N35 OE_ VDD VDD LPPFET L=0.12U W=0.34U
m36 N35 OE_ VSS VSS LPNFET L=0.12U W=0.18U
m37 N53 WE VDD VDD LPPFET L=0.12U W=0.42U
m38 N53 WE VSS VSS LPNFET L=0.12U W=0.22U
m39 DWI WEI VDD VDD LPPFET L=0.12U W=1.24U
m4 Q QPD VSS VSS LPNFET L=0.12U W=2.8U
m40 N80 WEI VSS VSS LPNFET L=0.12U W=1.12U
m41 DWI DI VDD VDD LPPFET L=0.12U W=1.24U
m42 DWI DI N80 VSS LPNFET L=0.12U W=1.12U
m43 DNWI WEI VDD VDD LPPFET L=0.12U W=1.24U
m44 N81 WEI VSS VSS LPNFET L=0.12U W=1.12U
m45 DNWI DNN VDD VDD LPPFET L=0.12U W=1.24U
m46 DNWI DNN N81 VSS LPNFET L=0.12U W=1.12U
m47 N48 D VDD VDD LPPFET L=0.12U W=0.5U
m48 N48 D VSS VSS LPNFET L=0.12U W=0.26U
m49 QPU OEI_ QI VDD LPPFET L=0.12U W=0.22U
m5 OEI_ N35 VDD VDD LPPFET L=0.12U W=0.94U
m50 QPD OEI QI VSS LPNFET L=0.12U W=0.27U
m51 DW DWPD VDD VDD LPPFET L=0.12U W=4.24U
m52 DW DWPD VSS VSS LPNFET L=0.12U W=2.12U
m53 DW_PU DW_ VDD VDD LPPFET L=0.18U W=0.16U
m54 DW_PU DW_ VSS VSS LPNFET L=0.66U W=0.16U
m55 DW_ DW_PU VDD VDD LPPFET L=0.12U W=4.24U
m56 DW_ DW_PU VSS VSS LPNFET L=0.12U W=2.12U
m57 BWE BWEN VDD VDD LPPFET L=0.12U W=1.56U
m58 BWE BWEN VSS VSS LPNFET L=0.12U W=0.78U
m6 OEI_ N35 VSS VSS LPNFET L=0.12U W=0.48U
m7 QPD OEI_ QI VDD LPPFET L=0.12U W=2.64U
m8 QPU OEI QI VSS LPNFET L=0.12U W=2.1U
m9 QPU OEI VDD VDD LPPFET L=0.12U W=1.12U
.ENDS SIGN_MEMIO8
****
.SUBCKT SIGN_MEMIOX D DPN DPU DW DW_ GTP OE_ Q SP STUBWEI VDD VSS
** SIGN_MEMIOX: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTP OE_ Q SP STUBWEI STUBWEI STUBWEI VDD VSS
+  SIGN_MEMIO8
.ENDS SIGN_MEMIOX
****
.SUBCKT SIGN_MEMFLSA GTP VDD VSS
** SIGN_MEMFLSA: 1 flat devices **
d1 VSS GTP tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFLSA
****
.SUBCKT SIGN_MEMSA8 DPN DPU DR DR_ DW DW_ GTP SP VDD VSS
** SIGN_MEMSA8: 41 flat devices **
m1 N22 SRCD VSS VSS LPNFET L=0.12U W=1.52U
m10 DPN SDN VDD VDD LPPFET L=0.12U W=1.54U
m11 DPN SDN VSS VSS LPNFET L=0.12U W=2.92U
m12 SP SPN VDD VDD LPPFET L=0.12U W=1.56U
m13 SP SPN VSS VSS LPNFET L=0.12U W=1.06U
m14 GTPN GTP VDD VDD LPPFET L=0.12U W=1U
m15 GTPN GTP VSS VSS LPNFET L=0.12U W=0.72U
m16 ND1 GTPN VDD VDD LPPFET L=0.12U W=0.52U
m17 ND1 GTPN VSS VSS LPNFET L=0.12U W=0.24U
m18 ND2 ND1 VDD VDD LPPFET L=0.12U W=0.34U
m19 ND2 ND1 VSS VSS LPNFET L=0.12U W=0.62U
m2 SD SP DR VDD LPPFET L=0.12U W=1.56U
m20 N40 DRP VSS VSS LPNFET L=0.12U W=0.98U
m21 SPN GTPN N40 VSS LPNFET L=0.12U W=0.68U
m22 SPN DRP VDD VDD LPPFET L=0.12U W=0.76U
m23 SPN GTPN VDD VDD LPPFET L=0.12U W=0.52U
m24 DRP ND2 VDD VDD LPPFET L=0.12U W=2.4U
m25 DRP ND2 VSS VSS LPNFET L=0.12U W=1U
m26 DR_ DRP VDD VDD LPPFET L=0.12U W=2.44U
m27 DR DRP VDD VDD LPPFET L=0.12U W=2.44U
m28 DR DRP DR_ VDD LPPFET L=0.12U W=2.44U
m29 SD_ SD SRC VSS LPNFET L=0.18U W=3.28U
m3 SD_ SP DR_ VDD LPPFET L=0.12U W=1.56U
m30 SD SD_ SRC VSS LPNFET L=0.18U W=3.28U
m31 SD_ SD SRC VSS LPNFET L=0.18U W=3.28U
m32 SD SD_ SRC VSS LPNFET L=0.18U W=3.28U
m33 SRC GTPN N22 VSS LPNFET L=0.12U W=1.66U
m34 SRCD SRCPU VDD VDD LPPFET L=0.12U W=0.46U
m35 SRCD SRCPU VSS VSS LPNFET L=0.12U W=0.22U
m36 SRCPU DRP VDD VDD LPPFET L=0.12U W=0.68U
m37 SRCPU DRP VSS VSS LPNFET L=0.12U W=0.26U
m38 VDD SRCPU SRC VSS LPNFET L=0.12U W=1.68U
m39 SD SRCD SD_ VDD LPPFET L=0.12U W=0.44U
m4 SD_ SD VDD VDD LPPFET L=0.12U W=0.84U
m40 SRC GTPN N52 VSS LPNFET L=0.12U W=1.66U
m41 N52 SRCD VSS VSS LPNFET L=0.12U W=1.52U
m5 SD SD_ VDD VDD LPPFET L=0.12U W=0.84U
m6 SDN SD VDD VDD LPPFET L=0.12U W=1.64U
m7 SDN SD VSS VSS LPNFET L=0.12U W=0.6U
m8 DPU SD_ VDD VDD LPPFET L=0.12U W=1.64U
m9 DPU SD_ VSS VSS LPNFET L=0.12U W=0.6U
.ENDS SIGN_MEMSA8
****
.SUBCKT SIGN_MEMCD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP
+  STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VDD VSS
** SIGN_MEMCD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD LPPFET L=0.12U W=2.16U
m10 BL1_ BL1PD VSS VSS LPNFET L=0.12U W=4.8U
m11 BL1_PD CS1 DW_ VDD LPPFET L=0.12U W=1.22U
m12 BL1_PD CS1 VSS VSS LPNFET L=0.12U W=0.64U
m13 BL1_ CS1 DR_ VDD LPPFET L=0.12U W=2.16U
m14 BL1PD CS1 DW VDD LPPFET L=0.12U W=1.22U
m15 BL1PD CS1 VSS VSS LPNFET L=0.12U W=0.64U
m16 BL1 BL1_PD VSS VSS LPNFET L=0.12U W=4.8U
m17 BL0_ YI VDD VDD LPPFET L=0.12U W=5U
m18 BL0 YI VDD VDD LPPFET L=0.12U W=5U
m19 BL0 YI BL0_ VDD LPPFET L=0.12U W=5U
m2 BL0 BL0PD VSS VSS LPNFET L=0.12U W=4.8U
m20 BL1 YI VDD VDD LPPFET L=0.12U W=5U
m21 BL1_ YI VDD VDD LPPFET L=0.12U W=5U
m22 BL1_ YI BL1 VDD LPPFET L=0.12U W=5U
m23 CS0 A0_ VDD VDD LPPFET L=0.12U W=1.48U
m24 N65 A0_ VSS VSS LPNFET L=0.12U W=1.52U
m25 CS0 YI VDD VDD LPPFET L=0.12U W=1.48U
m26 CS0 YI N65 VSS LPNFET L=0.12U W=1.52U
m27 CS1 A0 VDD VDD LPPFET L=0.12U W=1.48U
m28 N66 A0 VSS VSS LPNFET L=0.12U W=1.52U
m29 CS1 YI VDD VDD LPPFET L=0.12U W=1.48U
m3 BL0_PD CS0 DW VDD LPPFET L=0.12U W=1.22U
m30 CS1 YI N66 VSS LPNFET L=0.12U W=1.52U
m31 YCDSEL_ G0 VDD VDD LPPFET L=0.12U W=0.36U
m32 N67 G0 VSS VSS LPNFET L=0.12U W=0.34U
m33 YCDSEL_ G1 VDD VDD LPPFET L=0.12U W=0.36U
m34 YCDSEL_ G1 N67 VSS LPNFET L=0.12U W=0.34U
m35 YCDSEL YCDSEL_ VDD VDD LPPFET L=0.12U W=0.34U
m36 YCDSEL YCDSEL_ VSS VSS LPNFET L=0.12U W=0.16U
m37 N37 YCDSEL_ GTP VDD LPPFET L=0.12U W=0.78U
m38 N37 YCDSEL_ VSS VSS LPNFET L=0.12U W=0.28U
m39 YI WL1_EN_ VDD VDD LPPFET L=0.12U W=5.88U
m4 BL0_PD CS0 VSS VSS LPNFET L=0.12U W=0.64U
m40 YI WL1_EN_ VSS VSS LPNFET L=0.12U W=3.5U
m41 WL1_EN_ N37 VDD VDD LPPFET L=0.12U W=2.82U
m42 WL1_EN_ N37 VSS VSS LPNFET L=0.12U W=1.34U
m43 N37 YCDSEL GTP VSS LPNFET L=0.12U W=0.78U
m5 BL0 CS0 DR VDD LPPFET L=0.12U W=2.16U
m6 BL0PD CS0 DW_ VDD LPPFET L=0.12U W=1.22U
m7 BL0PD CS0 VSS VSS LPNFET L=0.12U W=0.64U
m8 BL0_ BL0_PD VSS VSS LPNFET L=0.12U W=4.8U
m9 BL1 CS1 DR VDD LPPFET L=0.12U W=2.16U
.ENDS SIGN_MEMCD
****
.SUBCKT SIGN_MEMCD2 A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1 GTP
+  STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VDD VSS
** SIGN_MEMCD2: 43 flat devices **
m1 BL0_ CS0 DR_ VDD LPPFET L=0.12U W=2.16U
m10 BL1_ BL1PD VSS VSS LPNFET L=0.12U W=4.8U
m11 BL1_PD CS1 DW_ VDD LPPFET L=0.12U W=1.22U
m12 BL1_PD CS1 VSS VSS LPNFET L=0.12U W=0.64U
m13 BL1_ CS1 DR_ VDD LPPFET L=0.12U W=2.16U
m14 BL1PD CS1 DW VDD LPPFET L=0.12U W=1.22U
m15 BL1PD CS1 VSS VSS LPNFET L=0.12U W=0.64U
m16 BL1 BL1_PD VSS VSS LPNFET L=0.12U W=4.8U
m17 BL0_ YI VDD VDD LPPFET L=0.12U W=5U
m18 BL0 YI VDD VDD LPPFET L=0.12U W=5U
m19 BL0 YI BL0_ VDD LPPFET L=0.12U W=5U
m2 BL0 BL0PD VSS VSS LPNFET L=0.12U W=4.8U
m20 BL1 YI VDD VDD LPPFET L=0.12U W=5U
m21 BL1_ YI VDD VDD LPPFET L=0.12U W=5U
m22 BL1_ YI BL1 VDD LPPFET L=0.12U W=5U
m23 CS0 A0_ VDD VDD LPPFET L=0.12U W=1.48U
m24 N65 A0_ VSS VSS LPNFET L=0.12U W=1.52U
m25 CS0 YI VDD VDD LPPFET L=0.12U W=1.48U
m26 CS0 YI N65 VSS LPNFET L=0.12U W=1.52U
m27 CS1 A0 VDD VDD LPPFET L=0.12U W=1.48U
m28 N66 A0 VSS VSS LPNFET L=0.12U W=1.52U
m29 CS1 YI VDD VDD LPPFET L=0.12U W=1.48U
m3 BL0_PD CS0 DW VDD LPPFET L=0.12U W=1.22U
m30 CS1 YI N66 VSS LPNFET L=0.12U W=1.52U
m31 YCDSEL_ G0 VDD VDD LPPFET L=0.12U W=0.36U
m32 N67 G0 VSS VSS LPNFET L=0.12U W=0.34U
m33 YCDSEL_ G1 VDD VDD LPPFET L=0.12U W=0.36U
m34 YCDSEL_ G1 N67 VSS LPNFET L=0.12U W=0.34U
m35 YCDSEL YCDSEL_ VDD VDD LPPFET L=0.12U W=0.34U
m36 YCDSEL YCDSEL_ VSS VSS LPNFET L=0.12U W=0.16U
m37 N37 YCDSEL_ GTP VDD LPPFET L=0.12U W=0.78U
m38 N37 YCDSEL_ VSS VSS LPNFET L=0.12U W=0.28U
m39 YI WL1_EN_ VDD VDD LPPFET L=0.12U W=5.88U
m4 BL0_PD CS0 VSS VSS LPNFET L=0.12U W=0.64U
m40 YI WL1_EN_ VSS VSS LPNFET L=0.12U W=3.5U
m41 WL1_EN_ N37 VDD VDD LPPFET L=0.12U W=2.82U
m42 WL1_EN_ N37 VSS VSS LPNFET L=0.12U W=1.34U
m43 N37 YCDSEL GTP VSS LPNFET L=0.12U W=0.78U
m5 BL0 CS0 DR VDD LPPFET L=0.12U W=2.16U
m6 BL0PD CS0 DW_ VDD LPPFET L=0.12U W=1.22U
m7 BL0PD CS0 VSS VSS LPNFET L=0.12U W=0.64U
m8 BL0_ BL0_PD VSS VSS LPNFET L=0.12U W=4.8U
m9 BL1 CS1 DR VDD LPPFET L=0.12U W=2.16U
.ENDS SIGN_MEMCD2
****
.SUBCKT SIGN_MEMMUX_CD_EVEN A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4
+  BL1__5 BL1__6 BL1__7 DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DRSA_5 DRSA_6
+  DRSA_7 DWSA_0 DWSA_1 DWSA_2 DWSA_3 DWSA_4 DWSA_5 DWSA_6 DWSA_7 GTP STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS
** SIGN_MEMMUX_CD_EVEN: 344 flat devices **
XI0_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_5 DRSA_0 DRSA_6 DWSA_5 DWSA_0
+  DWSA_6 YP0_0 VDD GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_5 DRSA_1 DRSA_6 DWSA_5 DWSA_1
+  DWSA_6 YP0_1 VDD GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI2_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_5 DRSA_2 DRSA_6 DWSA_5 DWSA_2
+  DWSA_6 YP0_2 VDD GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 DRSA_5 DRSA_3 DRSA_6 DWSA_5 DWSA_3
+  DWSA_6 YP0_3 VDD GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI4_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 DRSA_5 DRSA_4 DRSA_6 DWSA_5 DWSA_4
+  DWSA_6 VDD YP1_0 GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI5_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 DRSA_5 DRSA_5 DRSA_6 DWSA_5 DWSA_5
+  DWSA_6 VDD YP1_1 GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI6_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 DRSA_5 DRSA_6 DRSA_6 DWSA_5 DWSA_6
+  DWSA_6 VDD YP1_2 GTP DRSA_5 DRSA_6 DWSA_5 DWSA_6 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI7_0 A0 A0_ BL0_7 BL0__7 BL1_7 BL1__7 DRSA_5 DRSA_7 DRSA_6 DWSA_5 DWSA_7
+  DWSA_6 VDD YP1_3 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
.ENDS SIGN_MEMMUX_CD_EVEN
****
.SUBCKT SIGN_MEMCCEP BL BL_ WL WP VDD VSS
** SIGN_MEMCCEP: 6 flat devices **
m1 BL WP CORED VSS LPNFET L=0.13U W=0.16U
m2 BL_ WP CORED_ VSS LPNFET L=0.13U W=0.16U
m3 CORED_ CORED VDD VDD LPPFET L=0.12U W=0.15U
m4 CORED_ CORED VSS VSS LPNFET L=0.1U W=0.2U
m5 CORED CORED_ VDD VDD LPPFET L=0.12U W=0.15U
m6 CORED CORED_ VSS VSS LPNFET L=0.1U W=0.2U
.ENDS SIGN_MEMCCEP
****
.SUBCKT SIGN_MEMCCOG BL BL_ WL WP VDD VSS
** SIGN_MEMCCOG: 6 flat devices **
m1 BL WP CORED VSS LPNFET L=0.13U W=0.16U
m2 BL_ WP CORED_ VSS LPNFET L=0.13U W=0.16U
m3 CORED_ CORED VDD VDD LPPFET L=0.12U W=0.15U
m4 CORED_ CORED VSS VSS LPNFET L=0.1U W=0.2U
m5 CORED CORED_ VDD VDD LPPFET L=0.12U W=0.15U
m6 CORED CORED_ VSS VSS LPNFET L=0.1U W=0.2U
.ENDS SIGN_MEMCCOG
****
.SUBCKT SIGN_MEMCCEG BL BL_ WL WP VDD VSS
** SIGN_MEMCCEG: 6 flat devices **
m1 BL WP CORED VSS LPNFET L=0.13U W=0.16U
m2 BL_ WP CORED_ VSS LPNFET L=0.13U W=0.16U
m3 CORED_ CORED VDD VDD LPPFET L=0.12U W=0.15U
m4 CORED_ CORED VSS VSS LPNFET L=0.1U W=0.2U
m5 CORED CORED_ VDD VDD LPPFET L=0.12U W=0.15U
m6 CORED CORED_ VSS VSS LPNFET L=0.1U W=0.2U
.ENDS SIGN_MEMCCEG
****
.SUBCKT SIGN_MEMCCOP BL BL_ WL WP VDD VSS
** SIGN_MEMCCOP: 6 flat devices **
m1 BL WP CORED VSS LPNFET L=0.13U W=0.16U
m2 BL_ WP CORED_ VSS LPNFET L=0.13U W=0.16U
m3 CORED_ CORED VDD VDD LPPFET L=0.12U W=0.15U
m4 CORED_ CORED VSS VSS LPNFET L=0.1U W=0.2U
m5 CORED CORED_ VDD VDD LPPFET L=0.12U W=0.15U
m6 CORED CORED_ VSS VSS LPNFET L=0.1U W=0.2U
.ENDS SIGN_MEMCCOP
****
.SUBCKT SIGN_MEMBIT_MUX_3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL WP VDD
+  VSS
** SIGN_MEMBIT_MUX_3: 96 flat devices **
XI0_0 BL_0 BL__0 WL WP VDD VSS SIGN_MEMCCEG
XI10_0 BL_10 BL__10 WL WP VDD VSS SIGN_MEMCCEP
XI11_0 BL_11 BL__11 WL WP VDD VSS SIGN_MEMCCOG
XI12_0 BL_12 BL__12 WL WP VDD VSS SIGN_MEMCCEG
XI13_0 BL_13 BL__13 WL WP VDD VSS SIGN_MEMCCOP
XI14_0 BL_14 BL__14 WL WP VDD VSS SIGN_MEMCCEP
XI15_0 BL_15 BL__15 WL WP VDD VSS SIGN_MEMCCOG
XI1_0 BL_1 BL__1 WL WP VDD VSS SIGN_MEMCCOP
XI2_0 BL_2 BL__2 WL WP VDD VSS SIGN_MEMCCEP
XI3_0 BL_3 BL__3 WL WP VDD VSS SIGN_MEMCCOG
XI4_0 BL_4 BL__4 WL WP VDD VSS SIGN_MEMCCEG
XI5_0 BL_5 BL__5 WL WP VDD VSS SIGN_MEMCCOP
XI6_0 BL_6 BL__6 WL WP VDD VSS SIGN_MEMCCEP
XI7_0 BL_7 BL__7 WL WP VDD VSS SIGN_MEMCCOG
XI8_0 BL_8 BL__8 WL WP VDD VSS SIGN_MEMCCEG
XI9_0 BL_9 BL__9 WL WP VDD VSS SIGN_MEMCCOP
.ENDS SIGN_MEMBIT_MUX_3
****
.SUBCKT SIGN_MEMBIT_MUX_0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL WP VDD
+  VSS
** SIGN_MEMBIT_MUX_0: 96 flat devices **
XI0_0 BL_0 BL__0 WL WP VDD VSS SIGN_MEMCCEG
XI10_0 BL_10 BL__10 WL WP VDD VSS SIGN_MEMCCEP
XI11_0 BL_11 BL__11 WL WP VDD VSS SIGN_MEMCCOG
XI12_0 BL_12 BL__12 WL WP VDD VSS SIGN_MEMCCEG
XI13_0 BL_13 BL__13 WL WP VDD VSS SIGN_MEMCCOP
XI14_0 BL_14 BL__14 WL WP VDD VSS SIGN_MEMCCEP
XI15_0 BL_15 BL__15 WL WP VDD VSS SIGN_MEMCCOG
XI1_0 BL_1 BL__1 WL WP VDD VSS SIGN_MEMCCOP
XI2_0 BL_2 BL__2 WL WP VDD VSS SIGN_MEMCCEP
XI3_0 BL_3 BL__3 WL WP VDD VSS SIGN_MEMCCOG
XI4_0 BL_4 BL__4 WL WP VDD VSS SIGN_MEMCCEG
XI5_0 BL_5 BL__5 WL WP VDD VSS SIGN_MEMCCOP
XI6_0 BL_6 BL__6 WL WP VDD VSS SIGN_MEMCCEP
XI7_0 BL_7 BL__7 WL WP VDD VSS SIGN_MEMCCOG
XI8_0 BL_8 BL__8 WL WP VDD VSS SIGN_MEMCCEG
XI9_0 BL_9 BL__9 WL WP VDD VSS SIGN_MEMCCOP
.ENDS SIGN_MEMBIT_MUX_0
****
.SUBCKT SIGN_MEMBIT_MUX_1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL WP VDD
+  VSS
** SIGN_MEMBIT_MUX_1: 96 flat devices **
XI0_0 BL_0 BL__0 WL WP VDD VSS SIGN_MEMCCEG
XI10_0 BL_10 BL__10 WL WP VDD VSS SIGN_MEMCCEP
XI11_0 BL_11 BL__11 WL WP VDD VSS SIGN_MEMCCOG
XI12_0 BL_12 BL__12 WL WP VDD VSS SIGN_MEMCCEG
XI13_0 BL_13 BL__13 WL WP VDD VSS SIGN_MEMCCOP
XI14_0 BL_14 BL__14 WL WP VDD VSS SIGN_MEMCCEP
XI15_0 BL_15 BL__15 WL WP VDD VSS SIGN_MEMCCOG
XI1_0 BL_1 BL__1 WL WP VDD VSS SIGN_MEMCCOP
XI2_0 BL_2 BL__2 WL WP VDD VSS SIGN_MEMCCEP
XI3_0 BL_3 BL__3 WL WP VDD VSS SIGN_MEMCCOG
XI4_0 BL_4 BL__4 WL WP VDD VSS SIGN_MEMCCEG
XI5_0 BL_5 BL__5 WL WP VDD VSS SIGN_MEMCCOP
XI6_0 BL_6 BL__6 WL WP VDD VSS SIGN_MEMCCEP
XI7_0 BL_7 BL__7 WL WP VDD VSS SIGN_MEMCCOG
XI8_0 BL_8 BL__8 WL WP VDD VSS SIGN_MEMCCEG
XI9_0 BL_9 BL__9 WL WP VDD VSS SIGN_MEMCCOP
.ENDS SIGN_MEMBIT_MUX_1
****
.SUBCKT SIGN_MEMBIT_MUX_2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL WP VDD
+  VSS
** SIGN_MEMBIT_MUX_2: 96 flat devices **
XI0_0 BL_0 BL__0 WL WP VDD VSS SIGN_MEMCCEG
XI10_0 BL_10 BL__10 WL WP VDD VSS SIGN_MEMCCEP
XI11_0 BL_11 BL__11 WL WP VDD VSS SIGN_MEMCCOG
XI12_0 BL_12 BL__12 WL WP VDD VSS SIGN_MEMCCEG
XI13_0 BL_13 BL__13 WL WP VDD VSS SIGN_MEMCCOP
XI14_0 BL_14 BL__14 WL WP VDD VSS SIGN_MEMCCEP
XI15_0 BL_15 BL__15 WL WP VDD VSS SIGN_MEMCCOG
XI1_0 BL_1 BL__1 WL WP VDD VSS SIGN_MEMCCOP
XI2_0 BL_2 BL__2 WL WP VDD VSS SIGN_MEMCCEP
XI3_0 BL_3 BL__3 WL WP VDD VSS SIGN_MEMCCOG
XI4_0 BL_4 BL__4 WL WP VDD VSS SIGN_MEMCCEG
XI5_0 BL_5 BL__5 WL WP VDD VSS SIGN_MEMCCOP
XI6_0 BL_6 BL__6 WL WP VDD VSS SIGN_MEMCCEP
XI7_0 BL_7 BL__7 WL WP VDD VSS SIGN_MEMCCOG
XI8_0 BL_8 BL__8 WL WP VDD VSS SIGN_MEMCCEG
XI9_0 BL_9 BL__9 WL WP VDD VSS SIGN_MEMCCOP
.ENDS SIGN_MEMBIT_MUX_2
****
.SUBCKT SIGN_MEMBIT_COL BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 VDD VSS
** SIGN_MEMBIT_COL: 24576 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_0 WP_0 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_1 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_1 WP_1 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_10 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_10 WP_10 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_100 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_100 WP_100 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_101 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_101 WP_101 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_102 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_102 WP_102 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_103 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_103 WP_103 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_104 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_104 WP_104 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_105 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_105 WP_105 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_106 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_106 WP_106 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_107 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_107 WP_107 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_108 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_108 WP_108 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_109 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_109 WP_109 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_11 WP_11 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_110 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_110 WP_110 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_111 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_111 WP_111 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_112 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_112 WP_112 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_113 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_113 WP_113 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_114 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_114 WP_114 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_115 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_115 WP_115 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_116 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_116 WP_116 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_117 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_117 WP_117 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_118 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_118 WP_118 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_119 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_119 WP_119 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_12 WP_12 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_120 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_120 WP_120 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_121 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_121 WP_121 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_122 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_122 WP_122 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_123 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_123 WP_123 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_124 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_124 WP_124 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_125 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_125 WP_125 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_126 WP_126 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_127 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_127 WP_127 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_128 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_128 WP_128 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_129 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_129 WP_129 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_13 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_13 WP_13 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_130 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_130 WP_130 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_131 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_131 WP_131 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_132 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_132 WP_132 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_133 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_133 WP_133 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_134 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_134 WP_134 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_135 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_135 WP_135 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_136 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_136 WP_136 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_137 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_137 WP_137 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_138 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_138 WP_138 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_139 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_139 WP_139 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_14 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_14 WP_14 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_140 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_140 WP_140 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_141 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_141 WP_141 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_142 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_142 WP_142 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_143 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_143 WP_143 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_144 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_144 WP_144 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_145 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_145 WP_145 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_146 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_146 WP_146 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_147 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_147 WP_147 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_148 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_148 WP_148 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_149 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_149 WP_149 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_15 WP_15 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_150 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_150 WP_150 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_151 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_151 WP_151 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_152 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_152 WP_152 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_153 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_153 WP_153 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_154 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_154 WP_154 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_155 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_155 WP_155 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_156 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_156 WP_156 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_157 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_157 WP_157 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_158 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_158 WP_158 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_159 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_159 WP_159 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_16 WP_16 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_160 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_160 WP_160 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_161 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_161 WP_161 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_162 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_162 WP_162 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_163 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_163 WP_163 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_164 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_164 WP_164 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_165 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_165 WP_165 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_166 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_166 WP_166 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_167 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_167 WP_167 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_168 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_168 WP_168 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_169 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_169 WP_169 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_17 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_17 WP_17 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_170 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_170 WP_170 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_171 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_171 WP_171 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_172 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_172 WP_172 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_173 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_173 WP_173 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_174 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_174 WP_174 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_175 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_175 WP_175 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_176 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_176 WP_176 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_177 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_177 WP_177 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_178 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_178 WP_178 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_179 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_179 WP_179 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_18 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_18 WP_18 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_180 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_180 WP_180 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_181 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_181 WP_181 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_182 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_182 WP_182 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_183 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_183 WP_183 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_184 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_184 WP_184 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_185 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_185 WP_185 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_186 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_186 WP_186 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_187 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_187 WP_187 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_188 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_188 WP_188 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_189 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_189 WP_189 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_19 WP_19 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_190 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_190 WP_190 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_191 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_191 WP_191 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_192 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_192 WP_192 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_193 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_193 WP_193 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_194 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_194 WP_194 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_195 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_195 WP_195 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_196 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_196 WP_196 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_197 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_197 WP_197 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_198 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_198 WP_198 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_199 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_199 WP_199 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_2 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_2 WP_2 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_20 WP_20 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_200 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_200 WP_200 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_201 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_201 WP_201 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_202 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_202 WP_202 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_203 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_203 WP_203 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_204 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_204 WP_204 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_205 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_205 WP_205 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_206 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_206 WP_206 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_207 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_207 WP_207 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_208 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_208 WP_208 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_209 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_209 WP_209 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_21 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_21 WP_21 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_210 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_210 WP_210 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_211 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_211 WP_211 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_212 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_212 WP_212 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_213 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_213 WP_213 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_214 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_214 WP_214 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_215 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_215 WP_215 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_216 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_216 WP_216 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_217 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_217 WP_217 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_218 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_218 WP_218 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_219 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_219 WP_219 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_22 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_22 WP_22 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_220 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_220 WP_220 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_221 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_221 WP_221 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_222 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_222 WP_222 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_223 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_223 WP_223 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_224 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_224 WP_224 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_225 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_225 WP_225 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_226 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_226 WP_226 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_227 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_227 WP_227 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_228 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_228 WP_228 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_229 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_229 WP_229 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_23 WP_23 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_230 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_230 WP_230 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_231 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_231 WP_231 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_232 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_232 WP_232 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_233 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_233 WP_233 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_234 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_234 WP_234 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_235 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_235 WP_235 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_236 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_236 WP_236 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_237 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_237 WP_237 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_238 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_238 WP_238 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_239 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_239 WP_239 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_24 WP_24 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_240 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_240 WP_240 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_241 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_241 WP_241 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_242 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_242 WP_242 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_243 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_243 WP_243 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_244 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_244 WP_244 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_245 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_245 WP_245 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_246 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_246 WP_246 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_247 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_247 WP_247 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_248 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_248 WP_248 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_249 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_249 WP_249 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_25 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_25 WP_25 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_250 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_250 WP_250 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_251 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_251 WP_251 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_252 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_252 WP_252 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_253 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_253 WP_253 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_254 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_254 WP_254 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_255 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_255 WP_255 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_26 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_26 WP_26 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_27 WP_27 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_28 WP_28 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_29 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_29 WP_29 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_3 WP_3 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_30 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_30 WP_30 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_31 WP_31 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_32 WP_32 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_33 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_33 WP_33 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_34 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_34 WP_34 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_35 WP_35 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_36 WP_36 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_37 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_37 WP_37 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_38 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_38 WP_38 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_39 WP_39 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_4 WP_4 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_40 WP_40 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_41 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_41 WP_41 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_42 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_42 WP_42 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_43 WP_43 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_44 WP_44 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_45 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_45 WP_45 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_46 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_46 WP_46 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_47 WP_47 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_48 WP_48 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_49 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_49 WP_49 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_5 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_5 WP_5 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_50 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_50 WP_50 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_51 WP_51 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_52 WP_52 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_53 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_53 WP_53 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_54 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_54 WP_54 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_55 WP_55 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_56 WP_56 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_57 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_57 WP_57 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_58 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_58 WP_58 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_59 WP_59 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_6 WP_6 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_60 WP_60 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_61 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_61 WP_61 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_62 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_62 WP_62 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_63 WP_63 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_64 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_64 WP_64 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_65 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_65 WP_65 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_66 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_66 WP_66 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_67 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_67 WP_67 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_68 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_68 WP_68 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_69 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_69 WP_69 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_7 WP_7 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_70 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_70 WP_70 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_71 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_71 WP_71 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_72 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_72 WP_72 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_73 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_73 WP_73 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_74 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_74 WP_74 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_75 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_75 WP_75 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_76 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_76 WP_76 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_77 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_77 WP_77 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_78 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_78 WP_78 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_79 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_79 WP_79 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_8 WP_8 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_80 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_80 WP_80 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_81 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_81 WP_81 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_82 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_82 WP_82 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_83 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_83 WP_83 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_84 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_84 WP_84 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_85 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_85 WP_85 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_86 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_86 WP_86 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_87 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_87 WP_87 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_88 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_88 WP_88 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_89 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_89 WP_89 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_9 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_9 WP_9 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_90 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_90 WP_90 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_91 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_91 WP_91 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_92 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_92 WP_92 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_93 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_93 WP_93 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_94 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_94 WP_94 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_95 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_95 WP_95 VDD VSS
+  SIGN_MEMBIT_MUX_3
XI0_96 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_96 WP_96 VDD VSS
+  SIGN_MEMBIT_MUX_0
XI0_97 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_97 WP_97 VDD VSS
+  SIGN_MEMBIT_MUX_1
XI0_98 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL_98 WP_98 VDD VSS
+  SIGN_MEMBIT_MUX_2
XI0_99 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 WL_99 WP_99 VDD VSS
+  SIGN_MEMBIT_MUX_3
.ENDS SIGN_MEMBIT_COL
****
.SUBCKT SIGN_MEMMCOL_EVEN_LX16 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5
+  BLT_6 BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0
+  BLT__1 BLT__2 BLT__3 BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10
+  BLT__11 BLT__12 BLT__13 BLT__14 BLT__15 D GTP_0 GTP_1 GTP_2 OE_ Q STUBDR_0
+  STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 STUBWEI
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41
+  WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53
+  WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65
+  WP_66 WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77
+  WP_78 WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89
+  WP_90 WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101
+  WP_102 WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111
+  WP_112 WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121
+  WP_122 WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131
+  WP_132 WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141
+  WP_142 WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151
+  WP_152 WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161
+  WP_162 WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171
+  WP_172 WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181
+  WP_182 WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191
+  WP_192 WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201
+  WP_202 WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211
+  WP_212 WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221
+  WP_222 WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231
+  WP_232 WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241
+  WP_242 WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251
+  WP_252 WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VDD VSS
** SIGN_MEMMCOL_EVEN_LX16: 25026 flat devices **
XI0_0 VSS D Q VDD VSS SIGN_MEMFCBWLX
XI0_1 GTP_0 OE_ STUBWEI VDD VSS SIGN_MEMFLIO
XI0_2 GTP_1 VDD VSS SIGN_MEMFLSA
XI0_3 A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7
+  VSS VSS VSS VSS VSS STUBDR_1 STUBDR__1 VSS VSS VSS VSS VSS VSS STUBDW_1
+  STUBDW__1 VSS GTP_2 STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMUX_CD_EVEN
XI0_5 BL0_0 BL1__0 BL1__1 BL0_1 BL0_2 BL1__2 BL1__3 BL0_3 BL0_4 BL1__4 BL1__5
+  BL0_5 BL0_6 BL1__6 BL1__7 BL0_7 BL0__0 BL1_0 BL1_1 BL0__1 BL0__2 BL1_2
+  BL1_3 BL0__3 BL0__4 BL1_4 BL1_5 BL0__5 BL0__6 BL1_6 BL1_7 BL0__7 WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 VDD VSS SIGN_MEMBIT_COL
XI1_1 D DPN DPU STUBDW_1 STUBDW__1 GTP_0 OE_ Q SP STUBWEI VDD VSS SIGN_MEMIOX
XI1_2 DPN DPU STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 GTP_1 SP VDD VSS
+  SIGN_MEMSA8
.ENDS SIGN_MEMMCOL_EVEN_LX16
****
.SUBCKT SIGN_MEMFCBWM16 BWEN D Q VDD VSS
** SIGN_MEMFCBWM16: 2 flat devices **
d1 VSS Q tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS D tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCBWM16
****
.SUBCKT SIGN_MEMMUX_CD_ODD A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4
+  BL1__5 BL1__6 BL1__7 DRSA_0 DRSA_1 DRSA_2 DRSA_3 DRSA_4 DRSA_5 DWSA_0
+  DWSA_1 DWSA_2 DWSA_3 DWSA_4 DWSA_5 GTP STUBDR_0 STUBDR_1 STUBDR__0
+  STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMMUX_CD_ODD: 344 flat devices **
XI0_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 STUBDR_0 DRSA_0 STUBDR__0 STUBDW_0
+  DWSA_0 STUBDW__0 VDD YP1_3 GTP STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 STUBDR_0 DRSA_1 STUBDR__0 STUBDW_0
+  DWSA_1 STUBDW__0 VDD YP1_2 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI2_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 STUBDR_0 DRSA_2 STUBDR__0 STUBDW_0
+  DWSA_2 STUBDW__0 VDD YP1_1 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI3_0 A0 A0_ BL0_3 BL0__3 BL1_3 BL1__3 STUBDR_0 DRSA_3 STUBDR__0 STUBDW_0
+  DWSA_3 STUBDW__0 VDD YP1_0 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI4_0 A0 A0_ BL0_4 BL0__4 BL1_4 BL1__4 STUBDR_0 DRSA_4 STUBDR__0 STUBDW_0
+  DWSA_4 STUBDW__0 YP0_3 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI5_0 A0 A0_ BL0_5 BL0__5 BL1_5 BL1__5 STUBDR_0 STUBDR_0 STUBDR__0 STUBDW_0
+  STUBDW_0 STUBDW__0 YP0_2 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
XI6_0 A0 A0_ BL0_6 BL0__6 BL1_6 BL1__6 STUBDR_0 STUBDR__0 STUBDR__0 STUBDW_0
+  STUBDW__0 STUBDW__0 YP0_1 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD2
XI7_0 A0 A0_ BL0_7 BL0__7 BL1_7 BL1__7 STUBDR_0 DRSA_5 STUBDR__0 STUBDW_0
+  DWSA_5 STUBDW__0 YP0_0 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCD
.ENDS SIGN_MEMMUX_CD_ODD
****
.SUBCKT SIGN_MEMMCOL_ODD_M16 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6
+  BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0 BLT__1
+  BLT__2 BLT__3 BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10 BLT__11
+  BLT__12 BLT__13 BLT__14 BLT__15 D GTP_0 GTP_1 GTP_2 OE_ Q STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 STUBWEI WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS
** SIGN_MEMMCOL_ODD_M16: 25025 flat devices **
XI0_0 VSS D Q VDD VSS SIGN_MEMFCBWM16
XI0_1 GTP_0 OE_ STUBWEI VDD VSS SIGN_MEMFLIO
XI0_2 GTP_1 VDD VSS SIGN_MEMFLSA
XI0_3 A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS GTP_2 STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMUX_CD_ODD
XI0_5 BL0_7 BL1__7 BL1__6 BL0_6 BL0_5 BL1__5 BL1__4 BL0_4 BL0_3 BL1__3 BL1__2
+  BL0_2 BL0_1 BL1__1 BL1__0 BL0_0 BL0__7 BL1_7 BL1_6 BL0__6 BL0__5 BL1_5
+  BL1_4 BL0__4 BL0__3 BL1_3 BL1_2 BL0__2 BL0__1 BL1_1 BL1_0 BL0__0 WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 VDD VSS SIGN_MEMBIT_COL
XI1_1 D DPN DPU STUBDW_0 STUBDW__0 GTP_0 OE_ Q SP STUBWEI VDD VSS SIGN_MEMIOX
XI1_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_1 SP VDD VSS
+  SIGN_MEMSA8
.ENDS SIGN_MEMMCOL_ODD_M16
****
.SUBCKT SIGN_MEMMCOL_EVEN_M16 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6
+  BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0 BLT__1
+  BLT__2 BLT__3 BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10 BLT__11
+  BLT__12 BLT__13 BLT__14 BLT__15 D GTP_0 GTP_1 GTP_2 OE_ Q STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 STUBWEI WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS
** SIGN_MEMMCOL_EVEN_M16: 25025 flat devices **
XI0_0 VSS D Q VDD VSS SIGN_MEMFCBWM16
XI0_1 GTP_0 OE_ STUBWEI VDD VSS SIGN_MEMFLIO
XI0_2 GTP_1 VDD VSS SIGN_MEMFLSA
XI0_3 A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7
+  VSS VSS VSS VSS VSS STUBDR_1 STUBDR__1 VSS VSS VSS VSS VSS VSS STUBDW_1
+  STUBDW__1 VSS GTP_2 STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMUX_CD_EVEN
XI0_5 BL0_0 BL1__0 BL1__1 BL0_1 BL0_2 BL1__2 BL1__3 BL0_3 BL0_4 BL1__4 BL1__5
+  BL0_5 BL0_6 BL1__6 BL1__7 BL0_7 BL0__0 BL1_0 BL1_1 BL0__1 BL0__2 BL1_2
+  BL1_3 BL0__3 BL0__4 BL1_4 BL1_5 BL0__5 BL0__6 BL1_6 BL1_7 BL0__7 WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 VDD VSS SIGN_MEMBIT_COL
XI1_1 D DPN DPU STUBDW_1 STUBDW__1 GTP_0 OE_ Q SP STUBWEI VDD VSS SIGN_MEMIOX
XI1_2 DPN DPU STUBDR_1 STUBDR__1 STUBDW_1 STUBDW__1 GTP_1 SP VDD VSS
+  SIGN_MEMSA8
.ENDS SIGN_MEMMCOL_EVEN_M16
****
.SUBCKT SIGN_MEMFLCCSTRAP NDL NDR WL VDD VSS
** SIGN_MEMFLCCSTRAP: 2 flat devices **
m1 VSS WL NDL VSS LPNFET L=0.13U W=0.16U
m2 VSS WL NDR VSS LPNFET L=0.13U W=0.16U
.ENDS SIGN_MEMFLCCSTRAP
****
.SUBCKT SIGN_MEMBIT_COL_STRAP WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 VDD VSS
** SIGN_MEMBIT_COL_STRAP: 512 flat devices **
XI0_0 NDL_192 NDR_190 WL_0 VDD VSS SIGN_MEMFLCCSTRAP
XI0_1 NDL_192 NDR_190 WL_1 VDD VSS SIGN_MEMFLCCSTRAP
XI0_10 NDL_372 NDR_370 WL_10 VDD VSS SIGN_MEMFLCCSTRAP
XI0_100 NDL_12 NDR_10 WL_100 VDD VSS SIGN_MEMFLCCSTRAP
XI0_101 NDL_12 NDR_10 WL_101 VDD VSS SIGN_MEMFLCCSTRAP
XI0_102 NDL_16 NDR_14 WL_102 VDD VSS SIGN_MEMFLCCSTRAP
XI0_103 NDL_16 NDR_14 WL_103 VDD VSS SIGN_MEMFLCCSTRAP
XI0_104 NDL_20 NDR_18 WL_104 VDD VSS SIGN_MEMFLCCSTRAP
XI0_105 NDL_20 NDR_18 WL_105 VDD VSS SIGN_MEMFLCCSTRAP
XI0_106 NDL_24 NDR_22 WL_106 VDD VSS SIGN_MEMFLCCSTRAP
XI0_107 NDL_24 NDR_22 WL_107 VDD VSS SIGN_MEMFLCCSTRAP
XI0_108 NDL_32 NDR_30 WL_108 VDD VSS SIGN_MEMFLCCSTRAP
XI0_109 NDL_32 NDR_30 WL_109 VDD VSS SIGN_MEMFLCCSTRAP
XI0_11 NDL_372 NDR_370 WL_11 VDD VSS SIGN_MEMFLCCSTRAP
XI0_110 NDL_72 NDR_70 WL_110 VDD VSS SIGN_MEMFLCCSTRAP
XI0_111 NDL_72 NDR_70 WL_111 VDD VSS SIGN_MEMFLCCSTRAP
XI0_112 NDL_76 NDR_74 WL_112 VDD VSS SIGN_MEMFLCCSTRAP
XI0_113 NDL_76 NDR_74 WL_113 VDD VSS SIGN_MEMFLCCSTRAP
XI0_114 NDL_80 NDR_78 WL_114 VDD VSS SIGN_MEMFLCCSTRAP
XI0_115 NDL_80 NDR_78 WL_115 VDD VSS SIGN_MEMFLCCSTRAP
XI0_116 NDL_84 NDR_82 WL_116 VDD VSS SIGN_MEMFLCCSTRAP
XI0_117 NDL_84 NDR_82 WL_117 VDD VSS SIGN_MEMFLCCSTRAP
XI0_118 NDL_92 NDR_90 WL_118 VDD VSS SIGN_MEMFLCCSTRAP
XI0_119 NDL_92 NDR_90 WL_119 VDD VSS SIGN_MEMFLCCSTRAP
XI0_12 NDL_376 NDR_374 WL_12 VDD VSS SIGN_MEMFLCCSTRAP
XI0_120 NDL_136 NDR_134 WL_120 VDD VSS SIGN_MEMFLCCSTRAP
XI0_121 NDL_136 NDR_134 WL_121 VDD VSS SIGN_MEMFLCCSTRAP
XI0_122 NDL_144 NDR_142 WL_122 VDD VSS SIGN_MEMFLCCSTRAP
XI0_123 NDL_144 NDR_142 WL_123 VDD VSS SIGN_MEMFLCCSTRAP
XI0_124 NDL_152 NDR_150 WL_124 VDD VSS SIGN_MEMFLCCSTRAP
XI0_125 NDL_152 NDR_150 WL_125 VDD VSS SIGN_MEMFLCCSTRAP
XI0_126 NDL_160 NDR_158 WL_126 VDD VSS SIGN_MEMFLCCSTRAP
XI0_127 NDL_160 NDR_158 WL_127 VDD VSS SIGN_MEMFLCCSTRAP
XI0_128 NDL_168 NDR_166 WL_128 VDD VSS SIGN_MEMFLCCSTRAP
XI0_129 NDL_168 NDR_166 WL_129 VDD VSS SIGN_MEMFLCCSTRAP
XI0_13 NDL_376 NDR_374 WL_13 VDD VSS SIGN_MEMFLCCSTRAP
XI0_130 NDL_208 NDR_206 WL_130 VDD VSS SIGN_MEMFLCCSTRAP
XI0_131 NDL_208 NDR_206 WL_131 VDD VSS SIGN_MEMFLCCSTRAP
XI0_132 NDL_220 NDR_218 WL_132 VDD VSS SIGN_MEMFLCCSTRAP
XI0_133 NDL_220 NDR_218 WL_133 VDD VSS SIGN_MEMFLCCSTRAP
XI0_134 NDL_232 NDR_230 WL_134 VDD VSS SIGN_MEMFLCCSTRAP
XI0_135 NDL_232 NDR_230 WL_135 VDD VSS SIGN_MEMFLCCSTRAP
XI0_136 NDL_240 NDR_238 WL_136 VDD VSS SIGN_MEMFLCCSTRAP
XI0_137 NDL_240 NDR_238 WL_137 VDD VSS SIGN_MEMFLCCSTRAP
XI0_138 NDL_248 NDR_246 WL_138 VDD VSS SIGN_MEMFLCCSTRAP
XI0_139 NDL_248 NDR_246 WL_139 VDD VSS SIGN_MEMFLCCSTRAP
XI0_14 NDL_380 NDR_378 WL_14 VDD VSS SIGN_MEMFLCCSTRAP
XI0_140 NDL_276 NDR_274 WL_140 VDD VSS SIGN_MEMFLCCSTRAP
XI0_141 NDL_276 NDR_274 WL_141 VDD VSS SIGN_MEMFLCCSTRAP
XI0_142 NDL_284 NDR_282 WL_142 VDD VSS SIGN_MEMFLCCSTRAP
XI0_143 NDL_284 NDR_282 WL_143 VDD VSS SIGN_MEMFLCCSTRAP
XI0_144 NDL_292 NDR_290 WL_144 VDD VSS SIGN_MEMFLCCSTRAP
XI0_145 NDL_292 NDR_290 WL_145 VDD VSS SIGN_MEMFLCCSTRAP
XI0_146 NDL_300 NDR_298 WL_146 VDD VSS SIGN_MEMFLCCSTRAP
XI0_147 NDL_300 NDR_298 WL_147 VDD VSS SIGN_MEMFLCCSTRAP
XI0_148 NDL_308 NDR_306 WL_148 VDD VSS SIGN_MEMFLCCSTRAP
XI0_149 NDL_308 NDR_306 WL_149 VDD VSS SIGN_MEMFLCCSTRAP
XI0_15 NDL_380 NDR_378 WL_15 VDD VSS SIGN_MEMFLCCSTRAP
XI0_150 NDL_336 NDR_334 WL_150 VDD VSS SIGN_MEMFLCCSTRAP
XI0_151 NDL_336 NDR_334 WL_151 VDD VSS SIGN_MEMFLCCSTRAP
XI0_152 NDL_344 NDR_342 WL_152 VDD VSS SIGN_MEMFLCCSTRAP
XI0_153 NDL_344 NDR_342 WL_153 VDD VSS SIGN_MEMFLCCSTRAP
XI0_154 NDL_352 NDR_350 WL_154 VDD VSS SIGN_MEMFLCCSTRAP
XI0_155 NDL_352 NDR_350 WL_155 VDD VSS SIGN_MEMFLCCSTRAP
XI0_156 NDL_360 NDR_358 WL_156 VDD VSS SIGN_MEMFLCCSTRAP
XI0_157 NDL_360 NDR_358 WL_157 VDD VSS SIGN_MEMFLCCSTRAP
XI0_158 NDL_368 NDR_366 WL_158 VDD VSS SIGN_MEMFLCCSTRAP
XI0_159 NDL_368 NDR_366 WL_159 VDD VSS SIGN_MEMFLCCSTRAP
XI0_16 NDL_384 NDR_382 WL_16 VDD VSS SIGN_MEMFLCCSTRAP
XI0_160 NDL_416 NDR_414 WL_160 VDD VSS SIGN_MEMFLCCSTRAP
XI0_161 NDL_416 NDR_414 WL_161 VDD VSS SIGN_MEMFLCCSTRAP
XI0_162 NDL_424 NDR_422 WL_162 VDD VSS SIGN_MEMFLCCSTRAP
XI0_163 NDL_424 NDR_422 WL_163 VDD VSS SIGN_MEMFLCCSTRAP
XI0_164 NDL_432 NDR_430 WL_164 VDD VSS SIGN_MEMFLCCSTRAP
XI0_165 NDL_432 NDR_430 WL_165 VDD VSS SIGN_MEMFLCCSTRAP
XI0_166 NDL_440 NDR_438 WL_166 VDD VSS SIGN_MEMFLCCSTRAP
XI0_167 NDL_440 NDR_438 WL_167 VDD VSS SIGN_MEMFLCCSTRAP
XI0_168 NDL_448 NDR_446 WL_168 VDD VSS SIGN_MEMFLCCSTRAP
XI0_169 NDL_448 NDR_446 WL_169 VDD VSS SIGN_MEMFLCCSTRAP
XI0_17 NDL_384 NDR_382 WL_17 VDD VSS SIGN_MEMFLCCSTRAP
XI0_170 NDL_476 NDR_474 WL_170 VDD VSS SIGN_MEMFLCCSTRAP
XI0_171 NDL_476 NDR_474 WL_171 VDD VSS SIGN_MEMFLCCSTRAP
XI0_172 NDL_484 NDR_482 WL_172 VDD VSS SIGN_MEMFLCCSTRAP
XI0_173 NDL_484 NDR_482 WL_173 VDD VSS SIGN_MEMFLCCSTRAP
XI0_174 NDL_492 NDR_490 WL_174 VDD VSS SIGN_MEMFLCCSTRAP
XI0_175 NDL_492 NDR_490 WL_175 VDD VSS SIGN_MEMFLCCSTRAP
XI0_176 NDL_496 NDR_494 WL_176 VDD VSS SIGN_MEMFLCCSTRAP
XI0_177 NDL_496 NDR_494 WL_177 VDD VSS SIGN_MEMFLCCSTRAP
XI0_178 NDL_500 NDR_498 WL_178 VDD VSS SIGN_MEMFLCCSTRAP
XI0_179 NDL_500 NDR_498 WL_179 VDD VSS SIGN_MEMFLCCSTRAP
XI0_18 NDL_388 NDR_386 WL_18 VDD VSS SIGN_MEMFLCCSTRAP
XI0_180 NDL_28 NDR_26 WL_180 VDD VSS SIGN_MEMFLCCSTRAP
XI0_181 NDL_28 NDR_26 WL_181 VDD VSS SIGN_MEMFLCCSTRAP
XI0_182 NDL_36 NDR_34 WL_182 VDD VSS SIGN_MEMFLCCSTRAP
XI0_183 NDL_36 NDR_34 WL_183 VDD VSS SIGN_MEMFLCCSTRAP
XI0_184 NDL_40 NDR_38 WL_184 VDD VSS SIGN_MEMFLCCSTRAP
XI0_185 NDL_40 NDR_38 WL_185 VDD VSS SIGN_MEMFLCCSTRAP
XI0_186 NDL_44 NDR_42 WL_186 VDD VSS SIGN_MEMFLCCSTRAP
XI0_187 NDL_44 NDR_42 WL_187 VDD VSS SIGN_MEMFLCCSTRAP
XI0_188 NDL_48 NDR_46 WL_188 VDD VSS SIGN_MEMFLCCSTRAP
XI0_189 NDL_48 NDR_46 WL_189 VDD VSS SIGN_MEMFLCCSTRAP
XI0_19 NDL_388 NDR_386 WL_19 VDD VSS SIGN_MEMFLCCSTRAP
XI0_190 NDL_88 NDR_86 WL_190 VDD VSS SIGN_MEMFLCCSTRAP
XI0_191 NDL_88 NDR_86 WL_191 VDD VSS SIGN_MEMFLCCSTRAP
XI0_192 NDL_96 NDR_94 WL_192 VDD VSS SIGN_MEMFLCCSTRAP
XI0_193 NDL_96 NDR_94 WL_193 VDD VSS SIGN_MEMFLCCSTRAP
XI0_194 NDL_100 NDR_98 WL_194 VDD VSS SIGN_MEMFLCCSTRAP
XI0_195 NDL_100 NDR_98 WL_195 VDD VSS SIGN_MEMFLCCSTRAP
XI0_196 NDL_104 NDR_102 WL_196 VDD VSS SIGN_MEMFLCCSTRAP
XI0_197 NDL_104 NDR_102 WL_197 VDD VSS SIGN_MEMFLCCSTRAP
XI0_198 NDL_108 NDR_106 WL_198 VDD VSS SIGN_MEMFLCCSTRAP
XI0_199 NDL_108 NDR_106 WL_199 VDD VSS SIGN_MEMFLCCSTRAP
XI0_2 NDL_196 NDR_194 WL_2 VDD VSS SIGN_MEMFLCCSTRAP
XI0_20 NDL_452 NDR_450 WL_20 VDD VSS SIGN_MEMFLCCSTRAP
XI0_200 NDL_132 NDR_130 WL_200 VDD VSS SIGN_MEMFLCCSTRAP
XI0_201 NDL_132 NDR_130 WL_201 VDD VSS SIGN_MEMFLCCSTRAP
XI0_202 NDL_140 NDR_138 WL_202 VDD VSS SIGN_MEMFLCCSTRAP
XI0_203 NDL_140 NDR_138 WL_203 VDD VSS SIGN_MEMFLCCSTRAP
XI0_204 NDL_148 NDR_146 WL_204 VDD VSS SIGN_MEMFLCCSTRAP
XI0_205 NDL_148 NDR_146 WL_205 VDD VSS SIGN_MEMFLCCSTRAP
XI0_206 NDL_156 NDR_154 WL_206 VDD VSS SIGN_MEMFLCCSTRAP
XI0_207 NDL_156 NDR_154 WL_207 VDD VSS SIGN_MEMFLCCSTRAP
XI0_208 NDL_164 NDR_162 WL_208 VDD VSS SIGN_MEMFLCCSTRAP
XI0_209 NDL_164 NDR_162 WL_209 VDD VSS SIGN_MEMFLCCSTRAP
XI0_21 NDL_452 NDR_450 WL_21 VDD VSS SIGN_MEMFLCCSTRAP
XI0_210 NDL_200 NDR_198 WL_210 VDD VSS SIGN_MEMFLCCSTRAP
XI0_211 NDL_200 NDR_198 WL_211 VDD VSS SIGN_MEMFLCCSTRAP
XI0_212 NDL_212 NDR_210 WL_212 VDD VSS SIGN_MEMFLCCSTRAP
XI0_213 NDL_212 NDR_210 WL_213 VDD VSS SIGN_MEMFLCCSTRAP
XI0_214 NDL_224 NDR_222 WL_214 VDD VSS SIGN_MEMFLCCSTRAP
XI0_215 NDL_224 NDR_222 WL_215 VDD VSS SIGN_MEMFLCCSTRAP
XI0_216 NDL_236 NDR_234 WL_216 VDD VSS SIGN_MEMFLCCSTRAP
XI0_217 NDL_236 NDR_234 WL_217 VDD VSS SIGN_MEMFLCCSTRAP
XI0_218 NDL_244 NDR_242 WL_218 VDD VSS SIGN_MEMFLCCSTRAP
XI0_219 NDL_244 NDR_242 WL_219 VDD VSS SIGN_MEMFLCCSTRAP
XI0_22 NDL_456 NDR_454 WL_22 VDD VSS SIGN_MEMFLCCSTRAP
XI0_220 NDL_272 NDR_270 WL_220 VDD VSS SIGN_MEMFLCCSTRAP
XI0_221 NDL_272 NDR_270 WL_221 VDD VSS SIGN_MEMFLCCSTRAP
XI0_222 NDL_280 NDR_278 WL_222 VDD VSS SIGN_MEMFLCCSTRAP
XI0_223 NDL_280 NDR_278 WL_223 VDD VSS SIGN_MEMFLCCSTRAP
XI0_224 NDL_288 NDR_286 WL_224 VDD VSS SIGN_MEMFLCCSTRAP
XI0_225 NDL_288 NDR_286 WL_225 VDD VSS SIGN_MEMFLCCSTRAP
XI0_226 NDL_296 NDR_294 WL_226 VDD VSS SIGN_MEMFLCCSTRAP
XI0_227 NDL_296 NDR_294 WL_227 VDD VSS SIGN_MEMFLCCSTRAP
XI0_228 NDL_304 NDR_302 WL_228 VDD VSS SIGN_MEMFLCCSTRAP
XI0_229 NDL_304 NDR_302 WL_229 VDD VSS SIGN_MEMFLCCSTRAP
XI0_23 NDL_456 NDR_454 WL_23 VDD VSS SIGN_MEMFLCCSTRAP
XI0_230 NDL_332 NDR_330 WL_230 VDD VSS SIGN_MEMFLCCSTRAP
XI0_231 NDL_332 NDR_330 WL_231 VDD VSS SIGN_MEMFLCCSTRAP
XI0_232 NDL_340 NDR_338 WL_232 VDD VSS SIGN_MEMFLCCSTRAP
XI0_233 NDL_340 NDR_338 WL_233 VDD VSS SIGN_MEMFLCCSTRAP
XI0_234 NDL_348 NDR_346 WL_234 VDD VSS SIGN_MEMFLCCSTRAP
XI0_235 NDL_348 NDR_346 WL_235 VDD VSS SIGN_MEMFLCCSTRAP
XI0_236 NDL_356 NDR_354 WL_236 VDD VSS SIGN_MEMFLCCSTRAP
XI0_237 NDL_356 NDR_354 WL_237 VDD VSS SIGN_MEMFLCCSTRAP
XI0_238 NDL_364 NDR_362 WL_238 VDD VSS SIGN_MEMFLCCSTRAP
XI0_239 NDL_364 NDR_362 WL_239 VDD VSS SIGN_MEMFLCCSTRAP
XI0_24 NDL_460 NDR_458 WL_24 VDD VSS SIGN_MEMFLCCSTRAP
XI0_240 NDL_412 NDR_410 WL_240 VDD VSS SIGN_MEMFLCCSTRAP
XI0_241 NDL_412 NDR_410 WL_241 VDD VSS SIGN_MEMFLCCSTRAP
XI0_242 NDL_420 NDR_418 WL_242 VDD VSS SIGN_MEMFLCCSTRAP
XI0_243 NDL_420 NDR_418 WL_243 VDD VSS SIGN_MEMFLCCSTRAP
XI0_244 NDL_428 NDR_426 WL_244 VDD VSS SIGN_MEMFLCCSTRAP
XI0_245 NDL_428 NDR_426 WL_245 VDD VSS SIGN_MEMFLCCSTRAP
XI0_246 NDL_436 NDR_434 WL_246 VDD VSS SIGN_MEMFLCCSTRAP
XI0_247 NDL_436 NDR_434 WL_247 VDD VSS SIGN_MEMFLCCSTRAP
XI0_248 NDL_444 NDR_442 WL_248 VDD VSS SIGN_MEMFLCCSTRAP
XI0_249 NDL_444 NDR_442 WL_249 VDD VSS SIGN_MEMFLCCSTRAP
XI0_25 NDL_460 NDR_458 WL_25 VDD VSS SIGN_MEMFLCCSTRAP
XI0_250 NDL_472 NDR_470 WL_250 VDD VSS SIGN_MEMFLCCSTRAP
XI0_251 NDL_472 NDR_470 WL_251 VDD VSS SIGN_MEMFLCCSTRAP
XI0_252 NDL_480 NDR_478 WL_252 VDD VSS SIGN_MEMFLCCSTRAP
XI0_253 NDL_480 NDR_478 WL_253 VDD VSS SIGN_MEMFLCCSTRAP
XI0_254 NDL_488 NDR_486 WL_254 VDD VSS SIGN_MEMFLCCSTRAP
XI0_255 NDL_488 NDR_486 WL_255 VDD VSS SIGN_MEMFLCCSTRAP
XI0_26 NDL_464 NDR_462 WL_26 VDD VSS SIGN_MEMFLCCSTRAP
XI0_27 NDL_464 NDR_462 WL_27 VDD VSS SIGN_MEMFLCCSTRAP
XI0_28 NDL_468 NDR_466 WL_28 VDD VSS SIGN_MEMFLCCSTRAP
XI0_29 NDL_468 NDR_466 WL_29 VDD VSS SIGN_MEMFLCCSTRAP
XI0_3 NDL_196 NDR_194 WL_3 VDD VSS SIGN_MEMFLCCSTRAP
XI0_30 NDL_504 NDR_502 WL_30 VDD VSS SIGN_MEMFLCCSTRAP
XI0_31 NDL_504 NDR_502 WL_31 VDD VSS SIGN_MEMFLCCSTRAP
XI0_32 NDL_508 NDR_506 WL_32 VDD VSS SIGN_MEMFLCCSTRAP
XI0_33 NDL_508 NDR_506 WL_33 VDD VSS SIGN_MEMFLCCSTRAP
XI0_34 NDL NDR WL_34 VDD VSS SIGN_MEMFLCCSTRAP
XI0_35 NDL NDR WL_35 VDD VSS SIGN_MEMFLCCSTRAP
XI0_36 NDL_4 NDR_2 WL_36 VDD VSS SIGN_MEMFLCCSTRAP
XI0_37 NDL_4 NDR_2 WL_37 VDD VSS SIGN_MEMFLCCSTRAP
XI0_38 NDL_8 NDR_6 WL_38 VDD VSS SIGN_MEMFLCCSTRAP
XI0_39 NDL_8 NDR_6 WL_39 VDD VSS SIGN_MEMFLCCSTRAP
XI0_4 NDL_204 NDR_202 WL_4 VDD VSS SIGN_MEMFLCCSTRAP
XI0_40 NDL_52 NDR_50 WL_40 VDD VSS SIGN_MEMFLCCSTRAP
XI0_41 NDL_52 NDR_50 WL_41 VDD VSS SIGN_MEMFLCCSTRAP
XI0_42 NDL_56 NDR_54 WL_42 VDD VSS SIGN_MEMFLCCSTRAP
XI0_43 NDL_56 NDR_54 WL_43 VDD VSS SIGN_MEMFLCCSTRAP
XI0_44 NDL_60 NDR_58 WL_44 VDD VSS SIGN_MEMFLCCSTRAP
XI0_45 NDL_60 NDR_58 WL_45 VDD VSS SIGN_MEMFLCCSTRAP
XI0_46 NDL_64 NDR_62 WL_46 VDD VSS SIGN_MEMFLCCSTRAP
XI0_47 NDL_64 NDR_62 WL_47 VDD VSS SIGN_MEMFLCCSTRAP
XI0_48 NDL_68 NDR_66 WL_48 VDD VSS SIGN_MEMFLCCSTRAP
XI0_49 NDL_68 NDR_66 WL_49 VDD VSS SIGN_MEMFLCCSTRAP
XI0_5 NDL_204 NDR_202 WL_5 VDD VSS SIGN_MEMFLCCSTRAP
XI0_50 NDL_112 NDR_110 WL_50 VDD VSS SIGN_MEMFLCCSTRAP
XI0_51 NDL_112 NDR_110 WL_51 VDD VSS SIGN_MEMFLCCSTRAP
XI0_52 NDL_116 NDR_114 WL_52 VDD VSS SIGN_MEMFLCCSTRAP
XI0_53 NDL_116 NDR_114 WL_53 VDD VSS SIGN_MEMFLCCSTRAP
XI0_54 NDL_120 NDR_118 WL_54 VDD VSS SIGN_MEMFLCCSTRAP
XI0_55 NDL_120 NDR_118 WL_55 VDD VSS SIGN_MEMFLCCSTRAP
XI0_56 NDL_124 NDR_122 WL_56 VDD VSS SIGN_MEMFLCCSTRAP
XI0_57 NDL_124 NDR_122 WL_57 VDD VSS SIGN_MEMFLCCSTRAP
XI0_58 NDL_128 NDR_126 WL_58 VDD VSS SIGN_MEMFLCCSTRAP
XI0_59 NDL_128 NDR_126 WL_59 VDD VSS SIGN_MEMFLCCSTRAP
XI0_6 NDL_216 NDR_214 WL_6 VDD VSS SIGN_MEMFLCCSTRAP
XI0_60 NDL_172 NDR_170 WL_60 VDD VSS SIGN_MEMFLCCSTRAP
XI0_61 NDL_172 NDR_170 WL_61 VDD VSS SIGN_MEMFLCCSTRAP
XI0_62 NDL_176 NDR_174 WL_62 VDD VSS SIGN_MEMFLCCSTRAP
XI0_63 NDL_176 NDR_174 WL_63 VDD VSS SIGN_MEMFLCCSTRAP
XI0_64 NDL_180 NDR_178 WL_64 VDD VSS SIGN_MEMFLCCSTRAP
XI0_65 NDL_180 NDR_178 WL_65 VDD VSS SIGN_MEMFLCCSTRAP
XI0_66 NDL_184 NDR_182 WL_66 VDD VSS SIGN_MEMFLCCSTRAP
XI0_67 NDL_184 NDR_182 WL_67 VDD VSS SIGN_MEMFLCCSTRAP
XI0_68 NDL_188 NDR_186 WL_68 VDD VSS SIGN_MEMFLCCSTRAP
XI0_69 NDL_188 NDR_186 WL_69 VDD VSS SIGN_MEMFLCCSTRAP
XI0_7 NDL_216 NDR_214 WL_7 VDD VSS SIGN_MEMFLCCSTRAP
XI0_70 NDL_252 NDR_250 WL_70 VDD VSS SIGN_MEMFLCCSTRAP
XI0_71 NDL_252 NDR_250 WL_71 VDD VSS SIGN_MEMFLCCSTRAP
XI0_72 NDL_256 NDR_254 WL_72 VDD VSS SIGN_MEMFLCCSTRAP
XI0_73 NDL_256 NDR_254 WL_73 VDD VSS SIGN_MEMFLCCSTRAP
XI0_74 NDL_260 NDR_258 WL_74 VDD VSS SIGN_MEMFLCCSTRAP
XI0_75 NDL_260 NDR_258 WL_75 VDD VSS SIGN_MEMFLCCSTRAP
XI0_76 NDL_264 NDR_262 WL_76 VDD VSS SIGN_MEMFLCCSTRAP
XI0_77 NDL_264 NDR_262 WL_77 VDD VSS SIGN_MEMFLCCSTRAP
XI0_78 NDL_268 NDR_266 WL_78 VDD VSS SIGN_MEMFLCCSTRAP
XI0_79 NDL_268 NDR_266 WL_79 VDD VSS SIGN_MEMFLCCSTRAP
XI0_8 NDL_228 NDR_226 WL_8 VDD VSS SIGN_MEMFLCCSTRAP
XI0_80 NDL_312 NDR_310 WL_80 VDD VSS SIGN_MEMFLCCSTRAP
XI0_81 NDL_312 NDR_310 WL_81 VDD VSS SIGN_MEMFLCCSTRAP
XI0_82 NDL_316 NDR_314 WL_82 VDD VSS SIGN_MEMFLCCSTRAP
XI0_83 NDL_316 NDR_314 WL_83 VDD VSS SIGN_MEMFLCCSTRAP
XI0_84 NDL_320 NDR_318 WL_84 VDD VSS SIGN_MEMFLCCSTRAP
XI0_85 NDL_320 NDR_318 WL_85 VDD VSS SIGN_MEMFLCCSTRAP
XI0_86 NDL_324 NDR_322 WL_86 VDD VSS SIGN_MEMFLCCSTRAP
XI0_87 NDL_324 NDR_322 WL_87 VDD VSS SIGN_MEMFLCCSTRAP
XI0_88 NDL_328 NDR_326 WL_88 VDD VSS SIGN_MEMFLCCSTRAP
XI0_89 NDL_328 NDR_326 WL_89 VDD VSS SIGN_MEMFLCCSTRAP
XI0_9 NDL_228 NDR_226 WL_9 VDD VSS SIGN_MEMFLCCSTRAP
XI0_90 NDL_392 NDR_390 WL_90 VDD VSS SIGN_MEMFLCCSTRAP
XI0_91 NDL_392 NDR_390 WL_91 VDD VSS SIGN_MEMFLCCSTRAP
XI0_92 NDL_396 NDR_394 WL_92 VDD VSS SIGN_MEMFLCCSTRAP
XI0_93 NDL_396 NDR_394 WL_93 VDD VSS SIGN_MEMFLCCSTRAP
XI0_94 NDL_400 NDR_398 WL_94 VDD VSS SIGN_MEMFLCCSTRAP
XI0_95 NDL_400 NDR_398 WL_95 VDD VSS SIGN_MEMFLCCSTRAP
XI0_96 NDL_404 NDR_402 WL_96 VDD VSS SIGN_MEMFLCCSTRAP
XI0_97 NDL_404 NDR_402 WL_97 VDD VSS SIGN_MEMFLCCSTRAP
XI0_98 NDL_408 NDR_406 WL_98 VDD VSS SIGN_MEMFLCCSTRAP
XI0_99 NDL_408 NDR_406 WL_99 VDD VSS SIGN_MEMFLCCSTRAP
.ENDS SIGN_MEMBIT_COL_STRAP
****
.SUBCKT SIGN_MEMCOL_STRAPX A0 A0_ DR DR_ DW DW_ GTP_0 GTP_1 GTP_2 OE_ WE WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMCOL_STRAPX: 512 flat devices **
XI0_4 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 VDD VSS
+  SIGN_MEMBIT_COL_STRAP
.ENDS SIGN_MEMCOL_STRAPX
****
.SUBCKT SIGN_MEMWING_8_LEFT A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6
+  BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT_16 BLT_17
+  BLT_18 BLT_19 BLT_20 BLT_21 BLT_22 BLT_23 BLT_24 BLT_25 BLT_26 BLT_27
+  BLT_28 BLT_29 BLT_30 BLT_31 BLT_32 BLT_33 BLT_34 BLT_35 BLT_36 BLT_37
+  BLT_38 BLT_39 BLT_40 BLT_41 BLT_42 BLT_43 BLT_44 BLT_45 BLT_46 BLT_47
+  BLT_48 BLT_49 BLT_50 BLT_51 BLT_52 BLT_53 BLT_54 BLT_55 BLT_56 BLT_57
+  BLT_58 BLT_59 BLT_60 BLT_61 BLT_62 BLT_63 BLT_64 BLT_65 BLT_66 BLT_67
+  BLT_68 BLT_69 BLT_70 BLT_71 BLT_72 BLT_73 BLT_74 BLT_75 BLT_76 BLT_77
+  BLT_78 BLT_79 BLT_80 BLT_81 BLT_82 BLT_83 BLT_84 BLT_85 BLT_86 BLT_87
+  BLT_88 BLT_89 BLT_90 BLT_91 BLT_92 BLT_93 BLT_94 BLT_95 BLT_96 BLT_97
+  BLT_98 BLT_99 BLT_100 BLT_101 BLT_102 BLT_103 BLT_104 BLT_105 BLT_106
+  BLT_107 BLT_108 BLT_109 BLT_110 BLT_111 BLT_112 BLT_113 BLT_114 BLT_115
+  BLT_116 BLT_117 BLT_118 BLT_119 BLT_120 BLT_121 BLT_122 BLT_123 BLT_124
+  BLT_125 BLT_126 BLT_127 BLT__0 BLT__1 BLT__2 BLT__3 BLT__4 BLT__5 BLT__6
+  BLT__7 BLT__8 BLT__9 BLT__10 BLT__11 BLT__12 BLT__13 BLT__14 BLT__15
+  BLT__16 BLT__17 BLT__18 BLT__19 BLT__20 BLT__21 BLT__22 BLT__23 BLT__24
+  BLT__25 BLT__26 BLT__27 BLT__28 BLT__29 BLT__30 BLT__31 BLT__32 BLT__33
+  BLT__34 BLT__35 BLT__36 BLT__37 BLT__38 BLT__39 BLT__40 BLT__41 BLT__42
+  BLT__43 BLT__44 BLT__45 BLT__46 BLT__47 BLT__48 BLT__49 BLT__50 BLT__51
+  BLT__52 BLT__53 BLT__54 BLT__55 BLT__56 BLT__57 BLT__58 BLT__59 BLT__60
+  BLT__61 BLT__62 BLT__63 BLT__64 BLT__65 BLT__66 BLT__67 BLT__68 BLT__69
+  BLT__70 BLT__71 BLT__72 BLT__73 BLT__74 BLT__75 BLT__76 BLT__77 BLT__78
+  BLT__79 BLT__80 BLT__81 BLT__82 BLT__83 BLT__84 BLT__85 BLT__86 BLT__87
+  BLT__88 BLT__89 BLT__90 BLT__91 BLT__92 BLT__93 BLT__94 BLT__95 BLT__96
+  BLT__97 BLT__98 BLT__99 BLT__100 BLT__101 BLT__102 BLT__103 BLT__104
+  BLT__105 BLT__106 BLT__107 BLT__108 BLT__109 BLT__110 BLT__111 BLT__112
+  BLT__113 BLT__114 BLT__115 BLT__116 BLT__117 BLT__118 BLT__119 BLT__120
+  BLT__121 BLT__122 BLT__123 BLT__124 BLT__125 BLT__126 BLT__127 D_0 D_1 D_2
+  D_3 D_4 D_5 D_6 D_7 GTP_0 GTP_1 GTP_2 OE_ Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1
+  WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMWING_8_LEFT: 201737 flat devices **
XI0_0 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6 BLT_7 BLT_8 BLT_9
+  BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0 BLT__1 BLT__2 BLT__3
+  BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10 BLT__11 BLT__12 BLT__13
+  BLT__14 BLT__15 D_0 GTP_0 GTP_1 GTP_2 OE_ Q_0 STUBDR_0_10 STUBDR_1
+  STUBDR__0_8 STUBDR__1 STUBDW_0_12 STUBDW_1 STUBDW__0_14 STUBDW__1 WE WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS SIGN_MEMMCOL_ODD_M16
XI10_0 A0 A0_ BLT_127 BLT_126 BLT_125 BLT_124 BLT_123 BLT_122 BLT_121 BLT_120
+  BLT_119 BLT_118 BLT_117 BLT_116 BLT_115 BLT_114 BLT_113 BLT_112 BLT__127
+  BLT__126 BLT__125 BLT__124 BLT__123 BLT__122 BLT__121 BLT__120 BLT__119
+  BLT__118 BLT__117 BLT__116 BLT__115 BLT__114 BLT__113 BLT__112 D_7 GTP_0
+  GTP_1 GTP_2 OE_ Q_7 STUBDR_0_2 STUBDR_0 STUBDR__0_0 STUBDR__0 STUBDW_0_4
+  STUBDW_0 STUBDW__0_6 STUBDW__0 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_LX16
XI1_0 A0 A0_ BLT_31 BLT_30 BLT_29 BLT_28 BLT_27 BLT_26 BLT_25 BLT_24 BLT_23
+  BLT_22 BLT_21 BLT_20 BLT_19 BLT_18 BLT_17 BLT_16 BLT__31 BLT__30 BLT__29
+  BLT__28 BLT__27 BLT__26 BLT__25 BLT__24 BLT__23 BLT__22 BLT__21 BLT__20
+  BLT__19 BLT__18 BLT__17 BLT__16 D_1 GTP_0 GTP_1 GTP_2 OE_ Q_1 STUBDR_0_10
+  STUBDR_1_18 STUBDR__0_8 STUBDR__1_16 STUBDW_0_12 STUBDW_1_20 STUBDW__0_14
+  STUBDW__1_22 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_M16
XI2_0 A0 A0_ STUBDR_1_18 STUBDR__1_16 STUBDW_1_20 STUBDW__1_22 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI3_0 A0 A0_ BLT_32 BLT_33 BLT_34 BLT_35 BLT_36 BLT_37 BLT_38 BLT_39 BLT_40
+  BLT_41 BLT_42 BLT_43 BLT_44 BLT_45 BLT_46 BLT_47 BLT__32 BLT__33 BLT__34
+  BLT__35 BLT__36 BLT__37 BLT__38 BLT__39 BLT__40 BLT__41 BLT__42 BLT__43
+  BLT__44 BLT__45 BLT__46 BLT__47 D_2 GTP_0 GTP_1 GTP_2 OE_ Q_2 STUBDR_0_26
+  STUBDR_1_18 STUBDR__0_24 STUBDR__1_16 STUBDW_0_28 STUBDW_1_20 STUBDW__0_30
+  STUBDW__1_22 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_M16
XI4_0 A0 A0_ BLT_63 BLT_62 BLT_61 BLT_60 BLT_59 BLT_58 BLT_57 BLT_56 BLT_55
+  BLT_54 BLT_53 BLT_52 BLT_51 BLT_50 BLT_49 BLT_48 BLT__63 BLT__62 BLT__61
+  BLT__60 BLT__59 BLT__58 BLT__57 BLT__56 BLT__55 BLT__54 BLT__53 BLT__52
+  BLT__51 BLT__50 BLT__49 BLT__48 D_3 GTP_0 GTP_1 GTP_2 OE_ Q_3 STUBDR_0_26
+  STUBDR_1_34 STUBDR__0_24 STUBDR__1_32 STUBDW_0_28 STUBDW_1_36 STUBDW__0_30
+  STUBDW__1_38 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_M16
XI5_0 A0 A0_ STUBDR_1_34 STUBDR__1_32 STUBDW_1_36 STUBDW__1_38 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI6_0 A0 A0_ BLT_64 BLT_65 BLT_66 BLT_67 BLT_68 BLT_69 BLT_70 BLT_71 BLT_72
+  BLT_73 BLT_74 BLT_75 BLT_76 BLT_77 BLT_78 BLT_79 BLT__64 BLT__65 BLT__66
+  BLT__67 BLT__68 BLT__69 BLT__70 BLT__71 BLT__72 BLT__73 BLT__74 BLT__75
+  BLT__76 BLT__77 BLT__78 BLT__79 D_4 GTP_0 GTP_1 GTP_2 OE_ Q_4 STUBDR_0_42
+  STUBDR_1_34 STUBDR__0_40 STUBDR__1_32 STUBDW_0_44 STUBDW_1_36 STUBDW__0_46
+  STUBDW__1_38 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_M16
XI7_0 A0 A0_ BLT_95 BLT_94 BLT_93 BLT_92 BLT_91 BLT_90 BLT_89 BLT_88 BLT_87
+  BLT_86 BLT_85 BLT_84 BLT_83 BLT_82 BLT_81 BLT_80 BLT__95 BLT__94 BLT__93
+  BLT__92 BLT__91 BLT__90 BLT__89 BLT__88 BLT__87 BLT__86 BLT__85 BLT__84
+  BLT__83 BLT__82 BLT__81 BLT__80 D_5 GTP_0 GTP_1 GTP_2 OE_ Q_5 STUBDR_0_42
+  STUBDR_1_50 STUBDR__0_40 STUBDR__1_48 STUBDW_0_44 STUBDW_1_52 STUBDW__0_46
+  STUBDW__1_54 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_M16
XI8_0 A0 A0_ STUBDR_1_50 STUBDR__1_48 STUBDW_1_52 STUBDW__1_54 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI9_0 A0 A0_ BLT_96 BLT_97 BLT_98 BLT_99 BLT_100 BLT_101 BLT_102 BLT_103
+  BLT_104 BLT_105 BLT_106 BLT_107 BLT_108 BLT_109 BLT_110 BLT_111 BLT__96
+  BLT__97 BLT__98 BLT__99 BLT__100 BLT__101 BLT__102 BLT__103 BLT__104
+  BLT__105 BLT__106 BLT__107 BLT__108 BLT__109 BLT__110 BLT__111 D_6 GTP_0
+  GTP_1 GTP_2 OE_ Q_6 STUBDR_0_2 STUBDR_1_50 STUBDR__0_0 STUBDR__1_48
+  STUBDW_0_4 STUBDW_1_52 STUBDW__0_6 STUBDW__1_54 WE WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
+  SIGN_MEMMCOL_ODD_M16
.ENDS SIGN_MEMWING_8_LEFT
****
.SUBCKT SIGN_MEMADDR_CAP AGTPB AGTPT AY0 AY0_ GTP MWLB OEI_ WEI WL WL0_0 WL0_1
+  WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13
+  WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23
+  WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31 WL0_32 WL0_33
+  WL0_34 WL0_35 WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41 WL0_42 WL0_43
+  WL0_44 WL0_45 WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51 WL0_52 WL0_53
+  WL0_54 WL0_55 WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61 WL0_62 WL0_63
+  WL0_64 WL0_65 WL0_66 WL0_67 WL0_68 WL0_69 WL0_70 WL0_71 WL0_72 WL0_73
+  WL0_74 WL0_75 WL0_76 WL0_77 WL0_78 WL0_79 WL0_80 WL0_81 WL0_82 WL0_83
+  WL0_84 WL0_85 WL0_86 WL0_87 WL0_88 WL0_89 WL0_90 WL0_91 WL0_92 WL0_93
+  WL0_94 WL0_95 WL0_96 WL0_97 WL0_98 WL0_99 WL0_100 WL0_101 WL0_102 WL0_103
+  WL0_104 WL0_105 WL0_106 WL0_107 WL0_108 WL0_109 WL0_110 WL0_111 WL0_112
+  WL0_113 WL0_114 WL0_115 WL0_116 WL0_117 WL0_118 WL0_119 WL0_120 WL0_121
+  WL0_122 WL0_123 WL0_124 WL0_125 WL0_126 WL0_127 WL1_0 WL1_1 WL1_2 WL1_3
+  WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14
+  WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23 WL1_24
+  WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33 WL1_34
+  WL1_35 WL1_36 WL1_37 WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43 WL1_44
+  WL1_45 WL1_46 WL1_47 WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53 WL1_54
+  WL1_55 WL1_56 WL1_57 WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63 WL1_64
+  WL1_65 WL1_66 WL1_67 WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73 WL1_74
+  WL1_75 WL1_76 WL1_77 WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83 WL1_84
+  WL1_85 WL1_86 WL1_87 WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93 WL1_94
+  WL1_95 WL1_96 WL1_97 WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103 WL1_104
+  WL1_105 WL1_106 WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112 WL1_113
+  WL1_114 WL1_115 WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121 WL1_122
+  WL1_123 WL1_124 WL1_125 WL1_126 WL1_127 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS
** SIGN_MEMADDR_CAP: 258 flat devices **
XI0_10 NDL_185 WL0_4 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_100 NDL_5 WL1_49 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_101 NDL_5 WL0_49 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_102 NDL_7 WL0_50 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_103 NDL_7 WL1_50 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_104 NDL_9 WL1_51 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_105 NDL_9 WL0_51 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_106 NDL_11 WL0_52 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_107 NDL_11 WL1_52 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_108 NDL_15 WL1_53 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_109 NDL_15 WL0_53 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_11 NDL_185 WL1_4 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_110 NDL_37 WL0_54 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_111 NDL_37 WL1_54 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_112 NDL_39 WL1_55 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_113 NDL_39 WL0_55 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_114 NDL_41 WL0_56 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_115 NDL_41 WL1_56 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_116 NDL_43 WL1_57 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_117 NDL_43 WL0_57 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_118 NDL_45 WL0_58 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_119 NDL_45 WL1_58 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_12 NDL_187 WL1_5 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_120 NDL_69 WL1_59 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_121 NDL_69 WL0_59 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_122 NDL_73 WL0_60 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_123 NDL_73 WL1_60 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_124 NDL_77 WL1_61 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_125 NDL_77 WL0_61 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_126 NDL_81 WL0_62 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_127 NDL_81 WL1_62 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_128 NDL_85 WL1_63 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_129 NDL_85 WL0_63 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_13 NDL_187 WL0_5 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_130 NDL_103 WL0_64 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_131 NDL_103 WL1_64 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_132 NDL_109 WL1_65 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_133 NDL_109 WL0_65 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_134 NDL_115 WL0_66 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_135 NDL_115 WL1_66 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_136 NDL_119 WL1_67 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_137 NDL_119 WL0_67 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_138 NDL_123 WL0_68 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_139 NDL_123 WL1_68 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_14 NDL_189 WL0_6 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_140 NDL_137 WL1_69 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_141 NDL_137 WL0_69 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_142 NDL_141 WL0_70 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_143 NDL_141 WL1_70 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_144 NDL_145 WL1_71 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_145 NDL_145 WL0_71 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_146 NDL_149 WL0_72 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_147 NDL_149 WL1_72 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_148 NDL_153 WL1_73 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_149 NDL_153 WL0_73 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_15 NDL_189 WL1_6 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_150 NDL_167 WL0_74 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_151 NDL_167 WL1_74 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_152 NDL_171 WL1_75 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_153 NDL_171 WL0_75 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_154 NDL_175 WL0_76 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_155 NDL_175 WL1_76 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_156 NDL_179 WL1_77 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_157 NDL_179 WL0_77 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_158 NDL_183 WL0_78 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_159 NDL_183 WL1_78 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_16 NDL_191 WL1_7 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_160 NDL_207 WL1_79 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_161 NDL_207 WL0_79 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_162 NDL_211 WL0_80 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_163 NDL_211 WL1_80 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_164 NDL_215 WL1_81 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_165 NDL_215 WL0_81 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_166 NDL_219 WL0_82 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_167 NDL_219 WL1_82 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_168 NDL_223 WL1_83 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_169 NDL_223 WL0_83 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_17 NDL_191 WL0_7 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_170 NDL_237 WL0_84 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_171 NDL_237 WL1_84 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_172 NDL_241 WL1_85 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_173 NDL_241 WL0_85 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_174 NDL_245 WL0_86 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_175 NDL_245 WL1_86 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_176 NDL_249 WL1_87 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_177 NDL_249 WL0_87 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_178 NDL_251 WL0_88 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_179 NDL_251 WL1_88 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_18 NDL_193 WL0_8 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_180 NDL_17 WL1_89 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_181 NDL_17 WL0_89 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_182 NDL_19 WL0_90 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_183 NDL_19 WL1_90 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_184 NDL_21 WL1_91 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_185 NDL_21 WL0_91 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_186 NDL_23 WL0_92 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_187 NDL_23 WL1_92 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_188 NDL_25 WL1_93 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_189 NDL_25 WL0_93 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_19 NDL_193 WL1_8 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_190 NDL_47 WL0_94 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_191 NDL_47 WL1_94 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_192 NDL_49 WL1_95 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_193 NDL_49 WL0_95 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_194 NDL_51 WL0_96 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_195 NDL_51 WL1_96 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_196 NDL_53 WL1_97 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_197 NDL_53 WL0_97 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_198 NDL_55 WL0_98 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_199 NDL_55 WL1_98 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_2 NDL_97 WL0_0 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_20 NDL_225 WL1_9 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_200 NDL_67 WL1_99 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_201 NDL_67 WL0_99 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_202 NDL_71 WL0_100 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_203 NDL_71 WL1_100 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_204 NDL_75 WL1_101 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_205 NDL_75 WL0_101 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_206 NDL_79 WL0_102 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_207 NDL_79 WL1_102 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_208 NDL_83 WL1_103 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_209 NDL_83 WL0_103 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_21 NDL_225 WL0_9 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_210 NDL_99 WL0_104 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_211 NDL_99 WL1_104 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_212 NDL_105 WL1_105 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_213 NDL_105 WL0_105 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_214 NDL_111 WL0_106 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_215 NDL_111 WL1_106 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_216 NDL_117 WL1_107 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_217 NDL_117 WL0_107 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_218 NDL_121 WL0_108 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_219 NDL_121 WL1_108 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_22 NDL_227 WL0_10 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_220 NDL_135 WL1_109 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_221 NDL_135 WL0_109 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_222 NDL_139 WL0_110 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_223 NDL_139 WL1_110 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_224 NDL_143 WL1_111 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_225 NDL_143 WL0_111 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_226 NDL_147 WL0_112 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_227 NDL_147 WL1_112 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_228 NDL_151 WL1_113 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_229 NDL_151 WL0_113 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_23 NDL_227 WL1_10 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_230 NDL_165 WL0_114 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_231 NDL_165 WL1_114 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_232 NDL_169 WL1_115 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_233 NDL_169 WL0_115 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_234 NDL_173 WL0_116 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_235 NDL_173 WL1_116 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_236 NDL_177 WL1_117 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_237 NDL_177 WL0_117 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_238 NDL_181 WL0_118 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_239 NDL_181 WL1_118 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_24 NDL_229 WL1_11 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_240 NDL_205 WL1_119 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_241 NDL_205 WL0_119 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_242 NDL_209 WL0_120 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_243 NDL_209 WL1_120 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_244 NDL_213 WL1_121 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_245 NDL_213 WL0_121 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_246 NDL_217 WL0_122 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_247 NDL_217 WL1_122 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_248 NDL_221 WL1_123 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_249 NDL_221 WL0_123 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_25 NDL_229 WL0_11 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_250 NDL_235 WL0_124 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_251 NDL_235 WL1_124 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_252 NDL_239 WL1_125 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_253 NDL_239 WL0_125 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_254 NDL_243 WL0_126 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_255 NDL_243 WL1_126 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_256 NDL_247 WL1_127 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_257 NDL_247 WL0_127 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_259 NDL_13 MWLB VDD VSS SIGN_MEMFLCCSTRAPR
XI0_26 NDL_231 WL0_12 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_260 NDL_13 WL VDD VSS SIGN_MEMFLCCSTRAPR
XI0_27 NDL_231 WL1_12 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_28 NDL_233 WL1_13 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_29 NDL_233 WL0_13 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_3 NDL_97 WL1_0 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_30 NDL_253 WL0_14 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_31 NDL_253 WL1_14 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_32 NDL_255 WL1_15 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_33 NDL_255 WL0_15 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_34 NDL WL0_16 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_35 NDL WL1_16 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_36 NDL_1 WL1_17 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_37 NDL_1 WL0_17 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_38 NDL_3 WL0_18 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_39 NDL_3 WL1_18 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_4 NDL_101 WL1_1 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_40 NDL_27 WL1_19 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_41 NDL_27 WL0_19 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_42 NDL_29 WL0_20 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_43 NDL_29 WL1_20 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_44 NDL_31 WL1_21 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_45 NDL_31 WL0_21 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_46 NDL_33 WL0_22 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_47 NDL_33 WL1_22 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_48 NDL_35 WL1_23 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_49 NDL_35 WL0_23 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_5 NDL_101 WL0_1 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_50 NDL_57 WL0_24 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_51 NDL_57 WL1_24 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_52 NDL_59 WL1_25 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_53 NDL_59 WL0_25 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_54 NDL_61 WL0_26 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_55 NDL_61 WL1_26 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_56 NDL_63 WL1_27 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_57 NDL_63 WL0_27 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_58 NDL_65 WL0_28 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_59 NDL_65 WL1_28 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_6 NDL_107 WL0_2 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_60 NDL_87 WL1_29 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_61 NDL_87 WL0_29 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_62 NDL_89 WL0_30 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_63 NDL_89 WL1_30 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_64 NDL_91 WL1_31 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_65 NDL_91 WL0_31 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_66 NDL_93 WL0_32 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_67 NDL_93 WL1_32 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_68 NDL_95 WL1_33 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_69 NDL_95 WL0_33 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_7 NDL_107 WL1_2 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_70 NDL_125 WL0_34 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_71 NDL_125 WL1_34 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_72 NDL_127 WL1_35 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_73 NDL_127 WL0_35 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_74 NDL_129 WL0_36 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_75 NDL_129 WL1_36 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_76 NDL_131 WL1_37 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_77 NDL_131 WL0_37 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_78 NDL_133 WL0_38 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_79 NDL_133 WL1_38 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_8 NDL_113 WL1_3 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_80 NDL_155 WL1_39 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_81 NDL_155 WL0_39 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_82 NDL_157 WL0_40 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_83 NDL_157 WL1_40 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_84 NDL_159 WL1_41 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_85 NDL_159 WL0_41 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_86 NDL_161 WL0_42 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_87 NDL_161 WL1_42 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_88 NDL_163 WL1_43 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_89 NDL_163 WL0_43 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_9 NDL_113 WL0_3 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_90 NDL_195 WL0_44 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_91 NDL_195 WL1_44 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_92 NDL_197 WL1_45 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_93 NDL_197 WL0_45 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_94 NDL_199 WL0_46 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_95 NDL_199 WL1_46 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_96 NDL_201 WL1_47 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_97 NDL_201 WL0_47 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_98 NDL_203 WL0_48 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_99 NDL_203 WL1_48 VDD VSS SIGN_MEMFLCCSTRAPR
.ENDS SIGN_MEMADDR_CAP
****
.SUBCKT SIGN_MEMHXP24 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHXP24: 100 flat devices **
d15 VSS A1 tdndsx AREA=0.1024P PERIM=1.28U
d16 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d7 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
m1 N24 N31 VDD VDD LPPFET L=0.12U W=4.84U
m10 N28 N40 VSS VSS LPNFET L=0.12U W=2.44U
m100 XP_3 AP_I6-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m11 N27 A1 VDD VDD LPPFET L=0.12U W=4.84U
m12 N27 A1 VSS VSS LPNFET L=0.12U W=2.44U
m13 N40 A1 VDD VDD LPPFET L=0.12U W=3.88U
m14 N40 A1 VSS VSS LPNFET L=0.12U W=1.96U
m17 AP_I5-APN1 N57 AP_I5-AIND1 VSS LPNFET L=0.12U W=3.84U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD LPPFET L=0.12U W=6.42U
m19 N57 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m2 N24 N31 VSS VSS LPNFET L=0.12U W=2.44U
m20 N57 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m21 AP_I5-AIN21 N24 VDD VDD LPPFET L=0.12U W=3.56U
m22 AP_I5-AIN21 N24 VSS VSS LPNFET L=0.12U W=1.76U
m23 N51 N28 VDD VDD LPPFET L=0.12U W=3.56U
m24 N51 N28 VSS VSS LPNFET L=0.12U W=1.76U
m25 N52 VSS VDD VDD LPPFET L=0.12U W=3.56U
m26 N52 VSS VSS VSS LPNFET L=0.12U W=1.76U
m27 N86 N52 VSS VSS LPNFET L=0.12U W=3.82U
m28 N85 N51 N86 VSS LPNFET L=0.12U W=3.82U
m29 AP_I5-AIND1 AP_I5-AIN21 N85 VSS LPNFET L=0.12U W=3.82U
m3 N23 A0 VDD VDD LPPFET L=0.12U W=4.84U
m30 AP_I5-AIND1 N52 VDD VDD LPPFET L=0.12U W=6.4U
m31 N84 N52 VSS VSS LPNFET L=0.12U W=3.82U
m32 AP_I5-AIND1 N51 VDD VDD LPPFET L=0.12U W=6.4U
m33 N83 N51 N84 VSS LPNFET L=0.12U W=3.82U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m35 AP_I5-AIND1 AP_I5-AIN21 N83 VSS LPNFET L=0.12U W=3.82U
m36 AP_I5-APN0 N68 AP_I5-AIND0 VSS LPNFET L=0.12U W=3.84U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD LPPFET L=0.12U W=6.42U
m38 N68 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m39 N68 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m4 N23 A0 VSS VSS LPNFET L=0.12U W=2.44U
m40 AP_I5-AIN20 N23 VDD VDD LPPFET L=0.12U W=3.56U
m41 AP_I5-AIN20 N23 VSS VSS LPNFET L=0.12U W=1.76U
m42 N90 N52 VSS VSS LPNFET L=0.12U W=3.82U
m43 N89 N51 N90 VSS LPNFET L=0.12U W=3.82U
m44 AP_I5-AIND0 AP_I5-AIN20 N89 VSS LPNFET L=0.12U W=3.82U
m45 AP_I5-AIND0 N52 VDD VDD LPPFET L=0.12U W=6.4U
m46 N88 N52 VSS VSS LPNFET L=0.12U W=3.82U
m47 AP_I5-AIND0 N51 VDD VDD LPPFET L=0.12U W=6.4U
m48 N87 N51 N88 VSS LPNFET L=0.12U W=3.82U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m5 N31 A0 VDD VDD LPPFET L=0.12U W=3.88U
m50 AP_I5-AIND0 AP_I5-AIN20 N87 VSS LPNFET L=0.12U W=3.82U
m51 AP_I5-APN1 XP_0 VDD VDD LPPFET L=0.18U W=0.16U
m52 AP_I5-APN1 XP_0 VSS VSS LPNFET L=0.36U W=0.16U
m53 XP_0 AP_I5-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m54 XP_0 AP_I5-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m55 AP_I5-APN0 XP_1 VDD VDD LPPFET L=0.18U W=0.16U
m56 AP_I5-APN0 XP_1 VSS VSS LPNFET L=0.36U W=0.16U
m57 XP_1 AP_I5-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m58 XP_1 AP_I5-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m59 AP_I6-APN1 N99 AP_I6-AIND1 VSS LPNFET L=0.12U W=3.84U
m6 N31 A0 VSS VSS LPNFET L=0.12U W=1.96U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD LPPFET L=0.12U W=6.42U
m61 N99 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m62 N99 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m63 AP_I6-AIN21 N24 VDD VDD LPPFET L=0.12U W=3.56U
m64 AP_I6-AIN21 N24 VSS VSS LPNFET L=0.12U W=1.76U
m65 N93 N27 VDD VDD LPPFET L=0.12U W=3.56U
m66 N93 N27 VSS VSS LPNFET L=0.12U W=1.76U
m67 N94 VSS VDD VDD LPPFET L=0.12U W=3.56U
m68 N94 VSS VSS VSS LPNFET L=0.12U W=1.76U
m69 N128 N94 VSS VSS LPNFET L=0.12U W=3.82U
m70 N127 N93 N128 VSS LPNFET L=0.12U W=3.82U
m71 AP_I6-AIND1 AP_I6-AIN21 N127 VSS LPNFET L=0.12U W=3.82U
m72 AP_I6-AIND1 N94 VDD VDD LPPFET L=0.12U W=6.4U
m73 N126 N94 VSS VSS LPNFET L=0.12U W=3.82U
m74 AP_I6-AIND1 N93 VDD VDD LPPFET L=0.12U W=6.4U
m75 N125 N93 N126 VSS LPNFET L=0.12U W=3.82U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m77 AP_I6-AIND1 AP_I6-AIN21 N125 VSS LPNFET L=0.12U W=3.82U
m78 AP_I6-APN0 N110 AP_I6-AIND0 VSS LPNFET L=0.12U W=3.84U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD LPPFET L=0.12U W=6.42U
m80 N110 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m81 N110 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m82 AP_I6-AIN20 N23 VDD VDD LPPFET L=0.12U W=3.56U
m83 AP_I6-AIN20 N23 VSS VSS LPNFET L=0.12U W=1.76U
m84 N132 N94 VSS VSS LPNFET L=0.12U W=3.82U
m85 N131 N93 N132 VSS LPNFET L=0.12U W=3.82U
m86 AP_I6-AIND0 AP_I6-AIN20 N131 VSS LPNFET L=0.12U W=3.82U
m87 AP_I6-AIND0 N94 VDD VDD LPPFET L=0.12U W=6.4U
m88 N130 N94 VSS VSS LPNFET L=0.12U W=3.82U
m89 AP_I6-AIND0 N93 VDD VDD LPPFET L=0.12U W=6.4U
m9 N28 N40 VDD VDD LPPFET L=0.12U W=4.84U
m90 N129 N93 N130 VSS LPNFET L=0.12U W=3.82U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m92 AP_I6-AIND0 AP_I6-AIN20 N129 VSS LPNFET L=0.12U W=3.82U
m93 AP_I6-APN1 XP_2 VDD VDD LPPFET L=0.18U W=0.16U
m94 AP_I6-APN1 XP_2 VSS VSS LPNFET L=0.36U W=0.16U
m95 XP_2 AP_I6-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m96 XP_2 AP_I6-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m97 AP_I6-APN0 XP_3 VDD VDD LPPFET L=0.18U W=0.16U
m98 AP_I6-APN0 XP_3 VSS VSS LPNFET L=0.36U W=0.16U
m99 XP_3 AP_I6-APN0 VDD VDD LPPFET L=0.12U W=17.28U
.ENDS SIGN_MEMHXP24
****
.SUBCKT SIGN_MEMHXP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHXP24X: 100 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHXP24
.ENDS SIGN_MEMHXP24X
****
.SUBCKT SIGN_MEMHXP38 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VDD VSS
** SIGN_MEMHXP38: 192 flat devices **
d175 VSS A2 tdndsx AREA=0.1024P PERIM=1.28U
d176 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d183 VSS A1 tdndsx AREA=0.1024P PERIM=1.28U
d184 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d191 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d192 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
m1 AP67-APN1 N47 AP67-AIND1 VSS LPNFET L=0.12U W=3.84U
m10 N42 AI2_ VSS VSS LPNFET L=0.12U W=1.76U
m100 AP23-AIND1 N125 VDD VDD LPPFET L=0.12U W=6.4U
m101 N157 N125 N158 VSS LPNFET L=0.12U W=3.82U
m102 AP23-AIND1 AP23-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m103 AP23-AIND1 AP23-AIN21 N157 VSS LPNFET L=0.12U W=3.82U
m104 AP23-APN0 N142 AP23-AIND0 VSS LPNFET L=0.12U W=3.84U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD LPPFET L=0.12U W=6.42U
m106 N142 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m107 N142 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m108 AP23-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m109 AP23-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m11 N76 N42 VSS VSS LPNFET L=0.12U W=3.82U
m110 N164 N126 VSS VSS LPNFET L=0.12U W=3.82U
m111 N163 N125 N164 VSS LPNFET L=0.12U W=3.82U
m112 AP23-AIND0 AP23-AIN20 N163 VSS LPNFET L=0.12U W=3.82U
m113 AP23-AIND0 N126 VDD VDD LPPFET L=0.12U W=6.4U
m114 N162 N126 VSS VSS LPNFET L=0.12U W=3.82U
m115 AP23-AIND0 N125 VDD VDD LPPFET L=0.12U W=6.4U
m116 N161 N125 N162 VSS LPNFET L=0.12U W=3.82U
m117 AP23-AIND0 AP23-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m118 AP23-AIND0 AP23-AIN20 N161 VSS LPNFET L=0.12U W=3.82U
m119 AP23-APN1 XP_3 VDD VDD LPPFET L=0.18U W=0.16U
m12 N75 N41 N76 VSS LPNFET L=0.12U W=3.82U
m120 AP23-APN1 XP_3 VSS VSS LPNFET L=0.36U W=0.16U
m121 XP_3 AP23-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m122 XP_3 AP23-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m123 AP23-APN0 XP_2 VDD VDD LPPFET L=0.18U W=0.16U
m124 AP23-APN0 XP_2 VSS VSS LPNFET L=0.36U W=0.16U
m125 XP_2 AP23-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m126 XP_2 AP23-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m127 AP01-APN1 N173 AP01-AIND1 VSS LPNFET L=0.12U W=3.84U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD LPPFET L=0.12U W=6.42U
m129 N173 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m13 AP67-AIND1 AP67-AIN21 N75 VSS LPNFET L=0.12U W=3.82U
m130 N173 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m131 AP01-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m132 AP01-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m133 N167 AI1 VDD VDD LPPFET L=0.12U W=3.56U
m134 N167 AI1 VSS VSS LPNFET L=0.12U W=1.76U
m135 N168 AI2 VDD VDD LPPFET L=0.12U W=3.56U
m136 N168 AI2 VSS VSS LPNFET L=0.12U W=1.76U
m137 N202 N168 VSS VSS LPNFET L=0.12U W=3.82U
m138 N201 N167 N202 VSS LPNFET L=0.12U W=3.82U
m139 AP01-AIND1 AP01-AIN21 N201 VSS LPNFET L=0.12U W=3.82U
m14 AP67-AIND1 N42 VDD VDD LPPFET L=0.12U W=6.4U
m140 AP01-AIND1 N168 VDD VDD LPPFET L=0.12U W=6.4U
m141 N200 N168 VSS VSS LPNFET L=0.12U W=3.82U
m142 AP01-AIND1 N167 VDD VDD LPPFET L=0.12U W=6.4U
m143 N199 N167 N200 VSS LPNFET L=0.12U W=3.82U
m144 AP01-AIND1 AP01-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m145 AP01-AIND1 AP01-AIN21 N199 VSS LPNFET L=0.12U W=3.82U
m146 AP01-APN0 N184 AP01-AIND0 VSS LPNFET L=0.12U W=3.84U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD LPPFET L=0.12U W=6.42U
m148 N184 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m149 N184 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m15 N74 N42 VSS VSS LPNFET L=0.12U W=3.82U
m150 AP01-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m151 AP01-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m152 N206 N168 VSS VSS LPNFET L=0.12U W=3.82U
m153 N205 N167 N206 VSS LPNFET L=0.12U W=3.82U
m154 AP01-AIND0 AP01-AIN20 N205 VSS LPNFET L=0.12U W=3.82U
m155 AP01-AIND0 N168 VDD VDD LPPFET L=0.12U W=6.4U
m156 N204 N168 VSS VSS LPNFET L=0.12U W=3.82U
m157 AP01-AIND0 N167 VDD VDD LPPFET L=0.12U W=6.4U
m158 N203 N167 N204 VSS LPNFET L=0.12U W=3.82U
m159 AP01-AIND0 AP01-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m16 AP67-AIND1 N41 VDD VDD LPPFET L=0.12U W=6.4U
m160 AP01-AIND0 AP01-AIN20 N203 VSS LPNFET L=0.12U W=3.82U
m161 AP01-APN1 XP_1 VDD VDD LPPFET L=0.18U W=0.16U
m162 AP01-APN1 XP_1 VSS VSS LPNFET L=0.36U W=0.16U
m163 XP_1 AP01-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m164 XP_1 AP01-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m165 AP01-APN0 XP_0 VDD VDD LPPFET L=0.18U W=0.16U
m166 AP01-APN0 XP_0 VSS VSS LPNFET L=0.36U W=0.16U
m167 XP_0 AP01-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m168 XP_0 AP01-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m169 AI2 N207 VDD VDD LPPFET L=0.12U W=4.84U
m17 N73 N41 N74 VSS LPNFET L=0.12U W=3.82U
m170 AI2 N207 VSS VSS LPNFET L=0.12U W=2.44U
m171 AI2_ A2 VDD VDD LPPFET L=0.12U W=4.84U
m172 AI2_ A2 VSS VSS LPNFET L=0.12U W=2.44U
m173 N207 A2 VDD VDD LPPFET L=0.12U W=3.88U
m174 N207 A2 VSS VSS LPNFET L=0.12U W=1.96U
m177 AI1 N216 VDD VDD LPPFET L=0.12U W=4.84U
m178 AI1 N216 VSS VSS LPNFET L=0.12U W=2.44U
m179 AI1_ A1 VDD VDD LPPFET L=0.12U W=4.84U
m18 AP67-AIND1 AP67-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m180 AI1_ A1 VSS VSS LPNFET L=0.12U W=2.44U
m181 N216 A1 VDD VDD LPPFET L=0.12U W=3.88U
m182 N216 A1 VSS VSS LPNFET L=0.12U W=1.96U
m185 AI0 N225 VDD VDD LPPFET L=0.12U W=4.84U
m186 AI0 N225 VSS VSS LPNFET L=0.12U W=2.44U
m187 AI0_ A0 VDD VDD LPPFET L=0.12U W=4.84U
m188 AI0_ A0 VSS VSS LPNFET L=0.12U W=2.44U
m189 N225 A0 VDD VDD LPPFET L=0.12U W=3.88U
m19 AP67-AIND1 AP67-AIN21 N73 VSS LPNFET L=0.12U W=3.82U
m190 N225 A0 VSS VSS LPNFET L=0.12U W=1.96U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD LPPFET L=0.12U W=6.42U
m20 AP67-APN0 N58 AP67-AIND0 VSS LPNFET L=0.12U W=3.84U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD LPPFET L=0.12U W=6.42U
m22 N58 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m23 N58 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m24 AP67-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m25 AP67-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m26 N80 N42 VSS VSS LPNFET L=0.12U W=3.82U
m27 N79 N41 N80 VSS LPNFET L=0.12U W=3.82U
m28 AP67-AIND0 AP67-AIN20 N79 VSS LPNFET L=0.12U W=3.82U
m29 AP67-AIND0 N42 VDD VDD LPPFET L=0.12U W=6.4U
m3 N47 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m30 N78 N42 VSS VSS LPNFET L=0.12U W=3.82U
m31 AP67-AIND0 N41 VDD VDD LPPFET L=0.12U W=6.4U
m32 N77 N41 N78 VSS LPNFET L=0.12U W=3.82U
m33 AP67-AIND0 AP67-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m34 AP67-AIND0 AP67-AIN20 N77 VSS LPNFET L=0.12U W=3.82U
m35 AP67-APN1 XP_7 VDD VDD LPPFET L=0.18U W=0.16U
m36 AP67-APN1 XP_7 VSS VSS LPNFET L=0.36U W=0.16U
m37 XP_7 AP67-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m38 XP_7 AP67-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m39 AP67-APN0 XP_6 VDD VDD LPPFET L=0.18U W=0.16U
m4 N47 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m40 AP67-APN0 XP_6 VSS VSS LPNFET L=0.36U W=0.16U
m41 XP_6 AP67-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m42 XP_6 AP67-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m43 AP45-APN1 N89 AP45-AIND1 VSS LPNFET L=0.12U W=3.84U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD LPPFET L=0.12U W=6.42U
m45 N89 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m46 N89 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m47 AP45-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m48 AP45-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m49 N83 AI1 VDD VDD LPPFET L=0.12U W=3.56U
m5 AP67-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m50 N83 AI1 VSS VSS LPNFET L=0.12U W=1.76U
m51 N84 AI2_ VDD VDD LPPFET L=0.12U W=3.56U
m52 N84 AI2_ VSS VSS LPNFET L=0.12U W=1.76U
m53 N118 N84 VSS VSS LPNFET L=0.12U W=3.82U
m54 N117 N83 N118 VSS LPNFET L=0.12U W=3.82U
m55 AP45-AIND1 AP45-AIN21 N117 VSS LPNFET L=0.12U W=3.82U
m56 AP45-AIND1 N84 VDD VDD LPPFET L=0.12U W=6.4U
m57 N116 N84 VSS VSS LPNFET L=0.12U W=3.82U
m58 AP45-AIND1 N83 VDD VDD LPPFET L=0.12U W=6.4U
m59 N115 N83 N116 VSS LPNFET L=0.12U W=3.82U
m6 AP67-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m60 AP45-AIND1 AP45-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m61 AP45-AIND1 AP45-AIN21 N115 VSS LPNFET L=0.12U W=3.82U
m62 AP45-APN0 N100 AP45-AIND0 VSS LPNFET L=0.12U W=3.84U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD LPPFET L=0.12U W=6.42U
m64 N100 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m65 N100 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m66 AP45-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m67 AP45-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m68 N122 N84 VSS VSS LPNFET L=0.12U W=3.82U
m69 N121 N83 N122 VSS LPNFET L=0.12U W=3.82U
m7 N41 AI1_ VDD VDD LPPFET L=0.12U W=3.56U
m70 AP45-AIND0 AP45-AIN20 N121 VSS LPNFET L=0.12U W=3.82U
m71 AP45-AIND0 N84 VDD VDD LPPFET L=0.12U W=6.4U
m72 N120 N84 VSS VSS LPNFET L=0.12U W=3.82U
m73 AP45-AIND0 N83 VDD VDD LPPFET L=0.12U W=6.4U
m74 N119 N83 N120 VSS LPNFET L=0.12U W=3.82U
m75 AP45-AIND0 AP45-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m76 AP45-AIND0 AP45-AIN20 N119 VSS LPNFET L=0.12U W=3.82U
m77 AP45-APN1 XP_5 VDD VDD LPPFET L=0.18U W=0.16U
m78 AP45-APN1 XP_5 VSS VSS LPNFET L=0.36U W=0.16U
m79 XP_5 AP45-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m8 N41 AI1_ VSS VSS LPNFET L=0.12U W=1.76U
m80 XP_5 AP45-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m81 AP45-APN0 XP_4 VDD VDD LPPFET L=0.18U W=0.16U
m82 AP45-APN0 XP_4 VSS VSS LPNFET L=0.36U W=0.16U
m83 XP_4 AP45-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m84 XP_4 AP45-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m85 AP23-APN1 N131 AP23-AIND1 VSS LPNFET L=0.12U W=3.84U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD LPPFET L=0.12U W=6.42U
m87 N131 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m88 N131 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m89 AP23-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m9 N42 AI2_ VDD VDD LPPFET L=0.12U W=3.56U
m90 AP23-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m91 N125 AI1_ VDD VDD LPPFET L=0.12U W=3.56U
m92 N125 AI1_ VSS VSS LPNFET L=0.12U W=1.76U
m93 N126 AI2 VDD VDD LPPFET L=0.12U W=3.56U
m94 N126 AI2 VSS VSS LPNFET L=0.12U W=1.76U
m95 N160 N126 VSS VSS LPNFET L=0.12U W=3.82U
m96 N159 N125 N160 VSS LPNFET L=0.12U W=3.82U
m97 AP23-AIND1 AP23-AIN21 N159 VSS LPNFET L=0.12U W=3.82U
m98 AP23-AIND1 N126 VDD VDD LPPFET L=0.12U W=6.4U
m99 N158 N126 VSS VSS LPNFET L=0.12U W=3.82U
.ENDS SIGN_MEMHXP38
****
.SUBCKT SIGN_MEMHXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VDD VSS
** SIGN_MEMHXP38X: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4
+  XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
+  SIGN_MEMHXP38
.ENDS SIGN_MEMHXP38X
****
.SUBCKT SIGN_MEMX_PRE_DECODE A0_0 A0_1 A0_2 A1_0 A1_1 A1_2 A2_0 A2_1 AGTPB
+  AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_0_1 XP_0_2 XP_1_0 XP_1_1 XP_1_2
+  XP_2_0 XP_2_1 XP_2_2 XP_3_0 XP_3_1 XP_3_2 XP_4_0 XP_4_1 XP_5_0 XP_5_1
+  XP_6_0 XP_6_1 XP_7_0 XP_7_1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VDD VSS
** SIGN_MEMX_PRE_DECODE: 484 flat devices **
XI0_0 A0_0 A1_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHXP24X
XI1_0 A0_1 A1_1 A2_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_1 XP_1_1 XP_2_1
+  XP_3_1 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMHXP38X
XI2_0 A0_2 A1_2 A2_1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_2 XP_1_2 XP_2_2
+  XP_3_2 XP_4_1 XP_5_1 XP_6_1 XP_7_1 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMHXP38X
.ENDS SIGN_MEMX_PRE_DECODE
****
.SUBCKT SIGN_MEMHYP38 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHYP38: 192 flat devices **
d175 VSS A2 tdndsx AREA=0.1024P PERIM=1.28U
d176 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d183 VSS A1 tdndsx AREA=0.1024P PERIM=1.28U
d184 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
d191 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d192 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
m1 AP67-APN1 N39 AP67-AIND1 VSS LPNFET L=0.12U W=3.84U
m10 N34 AI2_ VSS VSS LPNFET L=0.12U W=1.76U
m100 AP23-AIND1 N117 VDD VDD LPPFET L=0.12U W=6.4U
m101 N149 N117 N150 VSS LPNFET L=0.12U W=3.82U
m102 AP23-AIND1 AP23-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m103 AP23-AIND1 AP23-AIN21 N149 VSS LPNFET L=0.12U W=3.82U
m104 AP23-APN0 N134 AP23-AIND0 VSS LPNFET L=0.12U W=3.84U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD LPPFET L=0.12U W=6.42U
m106 N134 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m107 N134 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m108 AP23-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m109 AP23-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m11 N68 N34 VSS VSS LPNFET L=0.12U W=3.82U
m110 N156 N118 VSS VSS LPNFET L=0.12U W=3.82U
m111 N155 N117 N156 VSS LPNFET L=0.12U W=3.82U
m112 AP23-AIND0 AP23-AIN20 N155 VSS LPNFET L=0.12U W=3.82U
m113 AP23-AIND0 N118 VDD VDD LPPFET L=0.12U W=6.4U
m114 N154 N118 VSS VSS LPNFET L=0.12U W=3.82U
m115 AP23-AIND0 N117 VDD VDD LPPFET L=0.12U W=6.4U
m116 N153 N117 N154 VSS LPNFET L=0.12U W=3.82U
m117 AP23-AIND0 AP23-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m118 AP23-AIND0 AP23-AIN20 N153 VSS LPNFET L=0.12U W=3.82U
m119 AP23-APN1 YP0_3 VDD VDD LPPFET L=0.18U W=0.16U
m12 N67 N33 N68 VSS LPNFET L=0.12U W=3.82U
m120 AP23-APN1 YP0_3 VSS VSS LPNFET L=0.36U W=0.16U
m121 YP0_3 AP23-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m122 YP0_3 AP23-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m123 AP23-APN0 YP0_2 VDD VDD LPPFET L=0.18U W=0.16U
m124 AP23-APN0 YP0_2 VSS VSS LPNFET L=0.36U W=0.16U
m125 YP0_2 AP23-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m126 YP0_2 AP23-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m127 AP01-APN1 N165 AP01-AIND1 VSS LPNFET L=0.12U W=3.84U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD LPPFET L=0.12U W=6.42U
m129 N165 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m13 AP67-AIND1 AP67-AIN21 N67 VSS LPNFET L=0.12U W=3.82U
m130 N165 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m131 AP01-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m132 AP01-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m133 N159 AI1 VDD VDD LPPFET L=0.12U W=3.56U
m134 N159 AI1 VSS VSS LPNFET L=0.12U W=1.76U
m135 N160 AI2 VDD VDD LPPFET L=0.12U W=3.56U
m136 N160 AI2 VSS VSS LPNFET L=0.12U W=1.76U
m137 N194 N160 VSS VSS LPNFET L=0.12U W=3.82U
m138 N193 N159 N194 VSS LPNFET L=0.12U W=3.82U
m139 AP01-AIND1 AP01-AIN21 N193 VSS LPNFET L=0.12U W=3.82U
m14 AP67-AIND1 N34 VDD VDD LPPFET L=0.12U W=6.4U
m140 AP01-AIND1 N160 VDD VDD LPPFET L=0.12U W=6.4U
m141 N192 N160 VSS VSS LPNFET L=0.12U W=3.82U
m142 AP01-AIND1 N159 VDD VDD LPPFET L=0.12U W=6.4U
m143 N191 N159 N192 VSS LPNFET L=0.12U W=3.82U
m144 AP01-AIND1 AP01-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m145 AP01-AIND1 AP01-AIN21 N191 VSS LPNFET L=0.12U W=3.82U
m146 AP01-APN0 N176 AP01-AIND0 VSS LPNFET L=0.12U W=3.84U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD LPPFET L=0.12U W=6.42U
m148 N176 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m149 N176 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m15 N66 N34 VSS VSS LPNFET L=0.12U W=3.82U
m150 AP01-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m151 AP01-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m152 N198 N160 VSS VSS LPNFET L=0.12U W=3.82U
m153 N197 N159 N198 VSS LPNFET L=0.12U W=3.82U
m154 AP01-AIND0 AP01-AIN20 N197 VSS LPNFET L=0.12U W=3.82U
m155 AP01-AIND0 N160 VDD VDD LPPFET L=0.12U W=6.4U
m156 N196 N160 VSS VSS LPNFET L=0.12U W=3.82U
m157 AP01-AIND0 N159 VDD VDD LPPFET L=0.12U W=6.4U
m158 N195 N159 N196 VSS LPNFET L=0.12U W=3.82U
m159 AP01-AIND0 AP01-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m16 AP67-AIND1 N33 VDD VDD LPPFET L=0.12U W=6.4U
m160 AP01-AIND0 AP01-AIN20 N195 VSS LPNFET L=0.12U W=3.82U
m161 AP01-APN1 YP0_1 VDD VDD LPPFET L=0.18U W=0.16U
m162 AP01-APN1 YP0_1 VSS VSS LPNFET L=0.36U W=0.16U
m163 YP0_1 AP01-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m164 YP0_1 AP01-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m165 AP01-APN0 YP0_0 VDD VDD LPPFET L=0.18U W=0.16U
m166 AP01-APN0 YP0_0 VSS VSS LPNFET L=0.36U W=0.16U
m167 YP0_0 AP01-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m168 YP0_0 AP01-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m169 AI2 N199 VDD VDD LPPFET L=0.12U W=4.84U
m17 N65 N33 N66 VSS LPNFET L=0.12U W=3.82U
m170 AI2 N199 VSS VSS LPNFET L=0.12U W=2.44U
m171 AI2_ A2 VDD VDD LPPFET L=0.12U W=4.84U
m172 AI2_ A2 VSS VSS LPNFET L=0.12U W=2.44U
m173 N199 A2 VDD VDD LPPFET L=0.12U W=3.88U
m174 N199 A2 VSS VSS LPNFET L=0.12U W=1.96U
m177 AI1 N208 VDD VDD LPPFET L=0.12U W=4.84U
m178 AI1 N208 VSS VSS LPNFET L=0.12U W=2.44U
m179 AI1_ A1 VDD VDD LPPFET L=0.12U W=4.84U
m18 AP67-AIND1 AP67-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m180 AI1_ A1 VSS VSS LPNFET L=0.12U W=2.44U
m181 N208 A1 VDD VDD LPPFET L=0.12U W=3.88U
m182 N208 A1 VSS VSS LPNFET L=0.12U W=1.96U
m185 AI0 N217 VDD VDD LPPFET L=0.12U W=4.84U
m186 AI0 N217 VSS VSS LPNFET L=0.12U W=2.44U
m187 AI0_ A0 VDD VDD LPPFET L=0.12U W=4.84U
m188 AI0_ A0 VSS VSS LPNFET L=0.12U W=2.44U
m189 N217 A0 VDD VDD LPPFET L=0.12U W=3.88U
m19 AP67-AIND1 AP67-AIN21 N65 VSS LPNFET L=0.12U W=3.82U
m190 N217 A0 VSS VSS LPNFET L=0.12U W=1.96U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD LPPFET L=0.12U W=6.42U
m20 AP67-APN0 N50 AP67-AIND0 VSS LPNFET L=0.12U W=3.84U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD LPPFET L=0.12U W=6.42U
m22 N50 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m23 N50 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m24 AP67-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m25 AP67-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m26 N72 N34 VSS VSS LPNFET L=0.12U W=3.82U
m27 N71 N33 N72 VSS LPNFET L=0.12U W=3.82U
m28 AP67-AIND0 AP67-AIN20 N71 VSS LPNFET L=0.12U W=3.82U
m29 AP67-AIND0 N34 VDD VDD LPPFET L=0.12U W=6.4U
m3 N39 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m30 N70 N34 VSS VSS LPNFET L=0.12U W=3.82U
m31 AP67-AIND0 N33 VDD VDD LPPFET L=0.12U W=6.4U
m32 N69 N33 N70 VSS LPNFET L=0.12U W=3.82U
m33 AP67-AIND0 AP67-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m34 AP67-AIND0 AP67-AIN20 N69 VSS LPNFET L=0.12U W=3.82U
m35 AP67-APN1 YP1_3 VDD VDD LPPFET L=0.18U W=0.16U
m36 AP67-APN1 YP1_3 VSS VSS LPNFET L=0.36U W=0.16U
m37 YP1_3 AP67-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m38 YP1_3 AP67-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m39 AP67-APN0 YP1_2 VDD VDD LPPFET L=0.18U W=0.16U
m4 N39 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m40 AP67-APN0 YP1_2 VSS VSS LPNFET L=0.36U W=0.16U
m41 YP1_2 AP67-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m42 YP1_2 AP67-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m43 AP45-APN1 N81 AP45-AIND1 VSS LPNFET L=0.12U W=3.84U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD LPPFET L=0.12U W=6.42U
m45 N81 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m46 N81 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m47 AP45-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m48 AP45-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m49 N75 AI1 VDD VDD LPPFET L=0.12U W=3.56U
m5 AP67-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m50 N75 AI1 VSS VSS LPNFET L=0.12U W=1.76U
m51 N76 AI2_ VDD VDD LPPFET L=0.12U W=3.56U
m52 N76 AI2_ VSS VSS LPNFET L=0.12U W=1.76U
m53 N110 N76 VSS VSS LPNFET L=0.12U W=3.82U
m54 N109 N75 N110 VSS LPNFET L=0.12U W=3.82U
m55 AP45-AIND1 AP45-AIN21 N109 VSS LPNFET L=0.12U W=3.82U
m56 AP45-AIND1 N76 VDD VDD LPPFET L=0.12U W=6.4U
m57 N108 N76 VSS VSS LPNFET L=0.12U W=3.82U
m58 AP45-AIND1 N75 VDD VDD LPPFET L=0.12U W=6.4U
m59 N107 N75 N108 VSS LPNFET L=0.12U W=3.82U
m6 AP67-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m60 AP45-AIND1 AP45-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m61 AP45-AIND1 AP45-AIN21 N107 VSS LPNFET L=0.12U W=3.82U
m62 AP45-APN0 N92 AP45-AIND0 VSS LPNFET L=0.12U W=3.84U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD LPPFET L=0.12U W=6.42U
m64 N92 AGTPB VDD VDD LPPFET L=0.12U W=0.9U
m65 N92 AGTPB VSS VSS LPNFET L=0.12U W=0.58U
m66 AP45-AIN20 AI0 VDD VDD LPPFET L=0.12U W=3.56U
m67 AP45-AIN20 AI0 VSS VSS LPNFET L=0.12U W=1.76U
m68 N114 N76 VSS VSS LPNFET L=0.12U W=3.82U
m69 N113 N75 N114 VSS LPNFET L=0.12U W=3.82U
m7 N33 AI1_ VDD VDD LPPFET L=0.12U W=3.56U
m70 AP45-AIND0 AP45-AIN20 N113 VSS LPNFET L=0.12U W=3.82U
m71 AP45-AIND0 N76 VDD VDD LPPFET L=0.12U W=6.4U
m72 N112 N76 VSS VSS LPNFET L=0.12U W=3.82U
m73 AP45-AIND0 N75 VDD VDD LPPFET L=0.12U W=6.4U
m74 N111 N75 N112 VSS LPNFET L=0.12U W=3.82U
m75 AP45-AIND0 AP45-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m76 AP45-AIND0 AP45-AIN20 N111 VSS LPNFET L=0.12U W=3.82U
m77 AP45-APN1 YP1_1 VDD VDD LPPFET L=0.18U W=0.16U
m78 AP45-APN1 YP1_1 VSS VSS LPNFET L=0.36U W=0.16U
m79 YP1_1 AP45-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m8 N33 AI1_ VSS VSS LPNFET L=0.12U W=1.76U
m80 YP1_1 AP45-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m81 AP45-APN0 YP1_0 VDD VDD LPPFET L=0.18U W=0.16U
m82 AP45-APN0 YP1_0 VSS VSS LPNFET L=0.36U W=0.16U
m83 YP1_0 AP45-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m84 YP1_0 AP45-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m85 AP23-APN1 N123 AP23-AIND1 VSS LPNFET L=0.12U W=3.84U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD LPPFET L=0.12U W=6.42U
m87 N123 AGTPT VDD VDD LPPFET L=0.12U W=0.9U
m88 N123 AGTPT VSS VSS LPNFET L=0.12U W=0.58U
m89 AP23-AIN21 AI0_ VDD VDD LPPFET L=0.12U W=3.56U
m9 N34 AI2_ VDD VDD LPPFET L=0.12U W=3.56U
m90 AP23-AIN21 AI0_ VSS VSS LPNFET L=0.12U W=1.76U
m91 N117 AI1_ VDD VDD LPPFET L=0.12U W=3.56U
m92 N117 AI1_ VSS VSS LPNFET L=0.12U W=1.76U
m93 N118 AI2 VDD VDD LPPFET L=0.12U W=3.56U
m94 N118 AI2 VSS VSS LPNFET L=0.12U W=1.76U
m95 N152 N118 VSS VSS LPNFET L=0.12U W=3.82U
m96 N151 N117 N152 VSS LPNFET L=0.12U W=3.82U
m97 AP23-AIND1 AP23-AIN21 N151 VSS LPNFET L=0.12U W=3.82U
m98 AP23-AIND1 N118 VDD VDD LPPFET L=0.12U W=6.4U
m99 N150 N118 VSS VSS LPNFET L=0.12U W=3.82U
.ENDS SIGN_MEMHYP38
****
.SUBCKT SIGN_MEMHYP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHYP38X: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHYP38
.ENDS SIGN_MEMHYP38X
****
.SUBCKT SIGN_MEMHYP12R A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHYP12R: 50 flat devices **
d7 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS BWEN tdndsx AREA=0.1024P PERIM=1.28U
m1 N22 N25 VDD VDD LPPFET L=0.12U W=4.84U
m10 AP01-APN1 AGTP AP01-AIND1 VDD LPPFET L=0.12U W=6.42U
m11 N42 AGTP VDD VDD LPPFET L=0.12U W=0.9U
m12 N42 AGTP VSS VSS LPNFET L=0.12U W=0.58U
m13 AP01-AIN21 N22 VDD VDD LPPFET L=0.12U W=3.56U
m14 AP01-AIN21 N22 VSS VSS LPNFET L=0.12U W=1.76U
m15 N36 VSS VDD VDD LPPFET L=0.12U W=3.56U
m16 N36 VSS VSS VSS LPNFET L=0.12U W=1.76U
m17 N37 VSS VDD VDD LPPFET L=0.12U W=3.56U
m18 N37 VSS VSS VSS LPNFET L=0.12U W=1.76U
m19 N71 N37 VSS VSS LPNFET L=0.12U W=3.82U
m2 N22 N25 VSS VSS LPNFET L=0.12U W=2.44U
m20 N70 N36 N71 VSS LPNFET L=0.12U W=3.82U
m21 AP01-AIND1 AP01-AIN21 N70 VSS LPNFET L=0.12U W=3.82U
m22 AP01-AIND1 N37 VDD VDD LPPFET L=0.12U W=6.4U
m23 N69 N37 VSS VSS LPNFET L=0.12U W=3.82U
m24 AP01-AIND1 N36 VDD VDD LPPFET L=0.12U W=6.4U
m25 N68 N36 N69 VSS LPNFET L=0.12U W=3.82U
m26 AP01-AIND1 AP01-AIN21 VDD VDD LPPFET L=0.12U W=6.4U
m27 AP01-AIND1 AP01-AIN21 N68 VSS LPNFET L=0.12U W=3.82U
m28 AP01-APN0 N53 AP01-AIND0 VSS LPNFET L=0.12U W=3.84U
m29 AP01-APN0 AGTP AP01-AIND0 VDD LPPFET L=0.12U W=6.42U
m3 N21 A0 VDD VDD LPPFET L=0.12U W=4.84U
m30 N53 AGTP VDD VDD LPPFET L=0.12U W=0.9U
m31 N53 AGTP VSS VSS LPNFET L=0.12U W=0.58U
m32 AP01-AIN20 N21 VDD VDD LPPFET L=0.12U W=3.56U
m33 AP01-AIN20 N21 VSS VSS LPNFET L=0.12U W=1.76U
m34 N75 N37 VSS VSS LPNFET L=0.12U W=3.82U
m35 N74 N36 N75 VSS LPNFET L=0.12U W=3.82U
m36 AP01-AIND0 AP01-AIN20 N74 VSS LPNFET L=0.12U W=3.82U
m37 AP01-AIND0 N37 VDD VDD LPPFET L=0.12U W=6.4U
m38 N73 N37 VSS VSS LPNFET L=0.12U W=3.82U
m39 AP01-AIND0 N36 VDD VDD LPPFET L=0.12U W=6.4U
m4 N21 A0 VSS VSS LPNFET L=0.12U W=2.44U
m40 N72 N36 N73 VSS LPNFET L=0.12U W=3.82U
m41 AP01-AIND0 AP01-AIN20 VDD VDD LPPFET L=0.12U W=6.4U
m42 AP01-AIND0 AP01-AIN20 N72 VSS LPNFET L=0.12U W=3.82U
m43 AP01-APN1 AY0_ VDD VDD LPPFET L=0.18U W=0.16U
m44 AP01-APN1 AY0_ VSS VSS LPNFET L=0.36U W=0.16U
m45 AY0_ AP01-APN1 VDD VDD LPPFET L=0.12U W=17.28U
m46 AY0_ AP01-APN1 VSS VSS LPNFET L=0.12U W=9.48U
m47 AP01-APN0 AY0 VDD VDD LPPFET L=0.18U W=0.16U
m48 AP01-APN0 AY0 VSS VSS LPNFET L=0.36U W=0.16U
m49 AY0 AP01-APN0 VDD VDD LPPFET L=0.12U W=17.28U
m5 N25 A0 VDD VDD LPPFET L=0.12U W=3.88U
m50 AY0 AP01-APN0 VSS VSS LPNFET L=0.12U W=9.48U
m6 N25 A0 VSS VSS LPNFET L=0.12U W=1.96U
m9 AP01-APN1 N42 AP01-AIND1 VSS LPNFET L=0.12U W=3.84U
.ENDS SIGN_MEMHYP12R
****
.SUBCKT SIGN_MEMHYP12RX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHYP12RX: 50 flat devices **
XI0_0 A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHYP12R
.ENDS SIGN_MEMHYP12RX
****
.SUBCKT SIGN_MEMY_DECODE A0_0 A0_1 A1 A2 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMY_DECODE: 242 flat devices **
XI0_0 A0_0 A1 A2 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHYP38X
XI1_0 A0_1 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMHYP12RX
.ENDS SIGN_MEMY_DECODE
****
.SUBCKT SIGN_MEMHBF8 CEN CLK GSRCN GTP GTPN MBL RST STOV STUBWE TMS WE WEI WEN
+  VDD VSS
** SIGN_MEMHBF8: 76 flat devices **
d72 VSS WEN tdndsx AREA=0.1024P PERIM=1.28U
d73 VSS CEN tdndsx AREA=0.1024P PERIM=1.28U
d74 VSS STOV tdndsx AREA=0.1024P PERIM=1.28U
d75 VSS CLK tdndsx AREA=0.1024P PERIM=1.28U
d76 VSS TMS tdndsx AREA=0.1024P PERIM=1.28U
m1 WE N31 VDD VDD LPPFET L=0.12U W=12.04U
m10 BF-RSRCN BF-CKSTOV N75 VSS LPNFET L=0.12U W=1.62U
m11 BF-RSRCN GTP VDD VDD LPPFET L=0.12U W=3.44U
m12 N74 GTP VSS VSS LPNFET L=0.12U W=1.62U
m13 BF-RSRCN BF-CKSTOV VDD VDD LPPFET L=0.12U W=3.44U
m14 BF-RSRCN BF-CKSTOV N74 VSS LPNFET L=0.12U W=1.62U
m15 BF-RSTSRC BF-RSRCN VDD VDD LPPFET L=0.12U W=8.6U
m16 BF-RSTSRC BF-RSRCN VSS VSS LPNFET L=0.12U W=4.1U
m17 BF-CKSTOV STOV VDD VDD LPPFET L=0.12U W=1.6U
m18 N76 STOV VSS VSS LPNFET L=0.12U W=1.54U
m19 BF-CKSTOV CLK VDD VDD LPPFET L=0.12U W=1.6U
m2 WE N31 VSS VSS LPNFET L=0.12U W=6.3U
m20 BF-CKSTOV CLK N76 VSS LPNFET L=0.12U W=1.54U
m21 GTPN BF-GTPI N44 VSS LPNFET L=0.12U W=0.16U
m22 N25 N25 VDD VDD LPPFET L=0.12U W=0.16U
m23 GTPN BF-GTPI VDD VDD LPPFET L=0.12U W=0.16U
m24 N25 VDD VDD VDD LPPFET L=0.12U W=0.16U
m25 BF-GTPI GTPN VDD VDD LPPFET L=0.12U W=0.32U
m26 BF-GTPI GTPN VSS VSS LPNFET L=0.12U W=0.16U
m27 N44 N25 VSS VSS LPNFET L=0.12U W=0.16U
m28 N78 BF-CLKN VSS VSS LPNFET L=0.12U W=2.1U
m29 GSRCN BF-CEL N78 VSS LPNFET L=0.12U W=2.1U
m3 BF-CENMML BF-CLKN N73 VDD LPPFET L=0.12U W=0.16U
m30 GSRCN BF-CLKN VDD VDD LPPFET L=0.12U W=3.56U
m31 N77 BF-CLKN VSS VSS LPNFET L=0.12U W=2.1U
m32 GSRCN BF-CEL VDD VDD LPPFET L=0.12U W=3.56U
m33 GSRCN BF-CEL N77 VSS LPNFET L=0.12U W=2.1U
m34 N53 BF-CLKN VSS VSS LPNFET L=0.12U W=0.54U
m35 N55 CLK VDD VDD LPPFET L=0.12U W=1.34U
m36 BF-CENMML N57 N58 VDD LPPFET L=0.12U W=1.34U
m37 BF-CENMML N57 N53 VSS LPNFET L=0.12U W=0.54U
m38 N58 TMS N55 VDD LPPFET L=0.12U W=1.34U
m39 BF-CENMML TMS N53 VSS LPNFET L=0.12U W=0.54U
m4 N73 BF-CEL VDD VDD LPPFET L=0.12U W=0.16U
m40 RST BF-MBLN VDD VDD LPPFET L=0.12U W=2.4U
m41 RST BF-RSTSRC VDD VDD LPPFET L=0.12U W=13.76U
m42 BF-MBLN MBL VDD VDD LPPFET L=0.12U W=5.7U
m43 BF-MBLN MBL VSS VSS LPNFET L=0.12U W=1.94U
m44 N63 WEN VDD VDD LPPFET L=0.12U W=1.8U
m45 N63 WEN VSS VSS LPNFET L=0.12U W=0.9U
m46 N57 CEN VDD VDD LPPFET L=0.12U W=0.6U
m47 N57 CEN VSS VSS LPNFET L=0.12U W=0.3U
m48 RST BF-MBLN N88 VSS LPNFET L=0.12U W=1.7U
m49 N88 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m5 BF-CENMML CLK N72 VSS LPNFET L=0.12U W=0.16U
m50 RST BF-MBLN N87 VSS LPNFET L=0.12U W=1.7U
m51 N87 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m52 RST BF-MBLN N86 VSS LPNFET L=0.12U W=1.7U
m53 N86 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m54 RST BF-MBLN N85 VSS LPNFET L=0.12U W=1.7U
m55 N85 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m56 RST BF-MBLN N84 VSS LPNFET L=0.12U W=1.7U
m57 N84 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m58 RST BF-MBLN N83 VSS LPNFET L=0.12U W=1.7U
m59 N83 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m6 N72 BF-CEL VSS VSS LPNFET L=0.12U W=0.16U
m60 RST BF-MBLN N82 VSS LPNFET L=0.12U W=1.7U
m61 N82 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m62 RST BF-MBLN N81 VSS LPNFET L=0.12U W=1.7U
m63 N81 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m64 RST BF-MBLN N80 VSS LPNFET L=0.12U W=1.7U
m65 N80 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m66 RST BF-MBLN N79 VSS LPNFET L=0.12U W=1.7U
m67 N79 BF-RSTSRC VSS VSS LPNFET L=0.12U W=2.2U
m68 N31 N63 VDD VDD LPPFET L=0.12U W=4.24U
m69 N31 N63 VSS VSS LPNFET L=0.12U W=2.02U
m7 BF-CEL BF-CENMML VDD VDD LPPFET L=0.12U W=1.62U
m70 BF-CLKN CLK VDD VDD LPPFET L=0.12U W=1.9U
m71 BF-CLKN CLK VSS VSS LPNFET L=0.36U W=0.92U
m8 BF-CEL BF-CENMML VSS VSS LPNFET L=0.12U W=0.86U
m9 N75 GTP VSS VSS LPNFET L=0.12U W=1.62U
.ENDS SIGN_MEMHBF8
****
.SUBCKT SIGN_MEMHBFX CEN CLK GSRCN GTP GTPN MBL RST STUBWE WEI WEN VDD VSS
** SIGN_MEMHBFX: 76 flat devices **
XI0_0 CEN CLK GSRCN GTP GTPN MBL RST VSS STUBWE VSS WEI WEI WEN VDD VSS
+  SIGN_MEMHBF8
.ENDS SIGN_MEMHBFX
****
.SUBCKT SIGN_MEMFLMWOG BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VDD VSS
** SIGN_MEMFLMWOG: 24 flat devices **
m1 N11 WP1 BL0 VSS LPNFET L=0.13U W=0.16U
m10 N13 N14 VSS VSS LPNFET L=0.1U W=0.2U
m11 N18 WP3 BL1_ VSS LPNFET L=0.13U W=0.16U
m12 N17 N18 VDD VDD LPPFET L=0.12U W=0.15U
m13 N17 N18 VSS VSS LPNFET L=0.1U W=0.2U
m14 N18 N17 VDD VDD LPPFET L=0.12U W=0.15U
m15 N18 N17 VSS VSS LPNFET L=0.1U W=0.2U
m16 N16 WP2 BL1_ VSS LPNFET L=0.13U W=0.16U
m17 N15 N16 VDD VDD LPPFET L=0.12U W=0.15U
m18 N15 N16 VSS VSS LPNFET L=0.1U W=0.2U
m19 N16 N15 VDD VDD LPPFET L=0.12U W=0.15U
m2 N12 N11 VDD VDD LPPFET L=0.12U W=0.15U
m20 N16 N15 VSS VSS LPNFET L=0.1U W=0.2U
m21 N12 WP3 BL0_ VSS LPNFET L=0.13U W=0.16U
m22 N14 WP2 BL0_ VSS LPNFET L=0.13U W=0.16U
m23 N17 WP3 BL1 VSS LPNFET L=0.13U W=0.16U
m24 N15 WP2 BL1 VSS LPNFET L=0.13U W=0.16U
m3 N12 N11 VSS VSS LPNFET L=0.1U W=0.2U
m4 N11 N12 VDD VDD LPPFET L=0.12U W=0.15U
m5 N11 N12 VSS VSS LPNFET L=0.1U W=0.2U
m6 N13 WP0 BL0 VSS LPNFET L=0.13U W=0.16U
m7 N14 N13 VDD VDD LPPFET L=0.12U W=0.15U
m8 N14 N13 VSS VSS LPNFET L=0.1U W=0.2U
m9 N13 N14 VDD VDD LPPFET L=0.12U W=0.15U
.ENDS SIGN_MEMFLMWOG
****
.SUBCKT SIGN_MEMMROW_8_LEFT BL0 BL0_ BL1 BL1_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 WL VDD VSS
** SIGN_MEMMROW_8_LEFT: 1548 flat devices **
XI0_0 BL_0 BL__0 WL WL VDD VSS SIGN_MEMCCOG
XI0_1 BL__0 BL_0 WL WL VDD VSS SIGN_MEMCCOG
XI100_0 BL_95 BL__95 VSS VSS VDD VSS SIGN_MEMCCEP
XI100_1 BL__95 BL_95 VSS VSS VDD VSS SIGN_MEMCCEP
XI101_0 BL_96 BL__96 VSS VSS VDD VSS SIGN_MEMCCOP
XI101_1 BL__96 BL_96 VSS VSS VDD VSS SIGN_MEMCCOP
XI102_0 BL_97 BL__97 VSS VSS VDD VSS SIGN_MEMCCEG
XI102_1 BL__97 BL_97 VSS VSS VDD VSS SIGN_MEMCCEG
XI103_0 BL_98 BL__98 VSS VSS VDD VSS SIGN_MEMCCOG
XI103_1 BL__98 BL_98 VSS VSS VDD VSS SIGN_MEMCCOG
XI104_0 BL_99 BL__99 VSS VSS VDD VSS SIGN_MEMCCEP
XI104_1 BL__99 BL_99 VSS VSS VDD VSS SIGN_MEMCCEP
XI105_0 BL_100 BL__100 VSS VSS VDD VSS SIGN_MEMCCOP
XI105_1 BL__100 BL_100 VSS VSS VDD VSS SIGN_MEMCCOP
XI106_0 BL_101 BL__101 VSS VSS VDD VSS SIGN_MEMCCEG
XI106_1 BL__101 BL_101 VSS VSS VDD VSS SIGN_MEMCCEG
XI107_0 BL_102 BL__102 VSS VSS VDD VSS SIGN_MEMCCOG
XI107_1 BL__102 BL_102 VSS VSS VDD VSS SIGN_MEMCCOG
XI108_0 BL_103 BL__103 VSS VSS VDD VSS SIGN_MEMCCEP
XI108_1 BL__103 BL_103 VSS VSS VDD VSS SIGN_MEMCCEP
XI109_0 BL_104 BL__104 VSS VSS VDD VSS SIGN_MEMCCOP
XI109_1 BL__104 BL_104 VSS VSS VDD VSS SIGN_MEMCCOP
XI10_0 BL_10 BL__10 WL WL VDD VSS SIGN_MEMCCOP
XI10_1 BL__10 BL_10 WL WL VDD VSS SIGN_MEMCCOP
XI110_0 BL_105 BL__105 VSS VSS VDD VSS SIGN_MEMCCEG
XI110_1 BL__105 BL_105 VSS VSS VDD VSS SIGN_MEMCCEG
XI111_0 BL_106 BL__106 VSS VSS VDD VSS SIGN_MEMCCOG
XI111_1 BL__106 BL_106 VSS VSS VDD VSS SIGN_MEMCCOG
XI112_0 BL_107 BL__107 VSS VSS VDD VSS SIGN_MEMCCEP
XI112_1 BL__107 BL_107 VSS VSS VDD VSS SIGN_MEMCCEP
XI113_0 BL_108 BL__108 VSS VSS VDD VSS SIGN_MEMCCOP
XI113_1 BL__108 BL_108 VSS VSS VDD VSS SIGN_MEMCCOP
XI114_0 BL_109 BL__109 VSS VSS VDD VSS SIGN_MEMCCEG
XI114_1 BL__109 BL_109 VSS VSS VDD VSS SIGN_MEMCCEG
XI115_0 BL_110 BL__110 VSS VSS VDD VSS SIGN_MEMCCOG
XI115_1 BL__110 BL_110 VSS VSS VDD VSS SIGN_MEMCCOG
XI116_0 BL_111 BL__111 VSS VSS VDD VSS SIGN_MEMCCEP
XI116_1 BL__111 BL_111 VSS VSS VDD VSS SIGN_MEMCCEP
XI117_0 BL_112 BL__112 VSS VSS VDD VSS SIGN_MEMCCOP
XI117_1 BL__112 BL_112 VSS VSS VDD VSS SIGN_MEMCCOP
XI118_0 BL_113 BL__113 VSS VSS VDD VSS SIGN_MEMCCEG
XI118_1 BL__113 BL_113 VSS VSS VDD VSS SIGN_MEMCCEG
XI119_0 BL_114 BL__114 VSS VSS VDD VSS SIGN_MEMCCOG
XI119_1 BL__114 BL_114 VSS VSS VDD VSS SIGN_MEMCCOG
XI11_0 BL_11 BL__11 WL WL VDD VSS SIGN_MEMCCEG
XI11_1 BL__11 BL_11 WL WL VDD VSS SIGN_MEMCCEG
XI120_0 BL_115 BL__115 VSS VSS VDD VSS SIGN_MEMCCEP
XI120_1 BL__115 BL_115 VSS VSS VDD VSS SIGN_MEMCCEP
XI121_0 BL_116 BL__116 VSS VSS VDD VSS SIGN_MEMCCOP
XI121_1 BL__116 BL_116 VSS VSS VDD VSS SIGN_MEMCCOP
XI122_0 BL_117 BL__117 VSS VSS VDD VSS SIGN_MEMCCEG
XI122_1 BL__117 BL_117 VSS VSS VDD VSS SIGN_MEMCCEG
XI123_0 BL_118 BL__118 VSS VSS VDD VSS SIGN_MEMCCOG
XI123_1 BL__118 BL_118 VSS VSS VDD VSS SIGN_MEMCCOG
XI124_0 BL_119 BL__119 VSS VSS VDD VSS SIGN_MEMCCEP
XI124_1 BL__119 BL_119 VSS VSS VDD VSS SIGN_MEMCCEP
XI125_0 BL_120 BL__120 VSS VSS VDD VSS SIGN_MEMCCOP
XI125_1 BL__120 BL_120 VSS VSS VDD VSS SIGN_MEMCCOP
XI126_0 BL_121 BL__121 VSS VSS VDD VSS SIGN_MEMCCEG
XI126_1 BL__121 BL_121 VSS VSS VDD VSS SIGN_MEMCCEG
XI127_0 BL_122 BL__122 VSS VSS VDD VSS SIGN_MEMCCOG
XI127_1 BL__122 BL_122 VSS VSS VDD VSS SIGN_MEMCCOG
XI128_0 BL_123 BL__123 VSS VSS VDD VSS SIGN_MEMCCEP
XI128_1 BL__123 BL_123 VSS VSS VDD VSS SIGN_MEMCCEP
XI129_0 BL_124 BL__124 VSS VSS VDD VSS SIGN_MEMCCOP
XI129_1 BL__124 BL_124 VSS VSS VDD VSS SIGN_MEMCCOP
XI12_0 BL_12 BL__12 WL WL VDD VSS SIGN_MEMCCOG
XI12_1 BL__12 BL_12 WL WL VDD VSS SIGN_MEMCCOG
XI130_0 BL_125 BL__125 VSS VSS VDD VSS SIGN_MEMCCEG
XI130_1 BL__125 BL_125 VSS VSS VDD VSS SIGN_MEMCCEG
XI13_0 BL_13 BL__13 WL WL VDD VSS SIGN_MEMCCEP
XI13_1 BL__13 BL_13 WL WL VDD VSS SIGN_MEMCCEP
XI14_0 BL_14 BL__14 WL WL VDD VSS SIGN_MEMCCOP
XI14_1 BL__14 BL_14 WL WL VDD VSS SIGN_MEMCCOP
XI15_0 BL_15 BL__15 WL WL VDD VSS SIGN_MEMCCEG
XI15_1 BL__15 BL_15 WL WL VDD VSS SIGN_MEMCCEG
XI16_0 BL_16 BL__16 WL WL VDD VSS SIGN_MEMCCOG
XI16_1 BL__16 BL_16 WL WL VDD VSS SIGN_MEMCCOG
XI17_0 BL_17 BL__17 WL WL VDD VSS SIGN_MEMCCEP
XI17_1 BL__17 BL_17 WL WL VDD VSS SIGN_MEMCCEP
XI18_0 BL_18 BL__18 WL WL VDD VSS SIGN_MEMCCOP
XI18_1 BL__18 BL_18 WL WL VDD VSS SIGN_MEMCCOP
XI19_0 BL_19 BL__19 WL WL VDD VSS SIGN_MEMCCEG
XI19_1 BL__19 BL_19 WL WL VDD VSS SIGN_MEMCCEG
XI1_0 BL_1 BL__1 WL WL VDD VSS SIGN_MEMCCEP
XI1_1 BL__1 BL_1 WL WL VDD VSS SIGN_MEMCCEP
XI20_0 BL_20 BL__20 WL WL VDD VSS SIGN_MEMCCOG
XI20_1 BL__20 BL_20 WL WL VDD VSS SIGN_MEMCCOG
XI21_0 BL_21 BL__21 WL WL VDD VSS SIGN_MEMCCEP
XI21_1 BL__21 BL_21 WL WL VDD VSS SIGN_MEMCCEP
XI22_0 BL_22 BL__22 WL WL VDD VSS SIGN_MEMCCOP
XI22_1 BL__22 BL_22 WL WL VDD VSS SIGN_MEMCCOP
XI23_0 BL_23 BL__23 WL WL VDD VSS SIGN_MEMCCEG
XI23_1 BL__23 BL_23 WL WL VDD VSS SIGN_MEMCCEG
XI24_0 BL_24 BL__24 WL WL VDD VSS SIGN_MEMCCOG
XI24_1 BL__24 BL_24 WL WL VDD VSS SIGN_MEMCCOG
XI25_0 BL_25 BL__25 WL WL VDD VSS SIGN_MEMCCEP
XI25_1 BL__25 BL_25 WL WL VDD VSS SIGN_MEMCCEP
XI26_0 BL_26 BL__26 WL WL VDD VSS SIGN_MEMCCOP
XI26_1 BL__26 BL_26 WL WL VDD VSS SIGN_MEMCCOP
XI27_0 BL_27 BL__27 WL WL VDD VSS SIGN_MEMCCEG
XI27_1 BL__27 BL_27 WL WL VDD VSS SIGN_MEMCCEG
XI28_0 BL_28 BL__28 WL WL VDD VSS SIGN_MEMCCOG
XI28_1 BL__28 BL_28 WL WL VDD VSS SIGN_MEMCCOG
XI29_0 BL_29 BL__29 WL WL VDD VSS SIGN_MEMCCEP
XI29_1 BL__29 BL_29 WL WL VDD VSS SIGN_MEMCCEP
XI2_0 BL_2 BL__2 WL WL VDD VSS SIGN_MEMCCOP
XI2_1 BL__2 BL_2 WL WL VDD VSS SIGN_MEMCCOP
XI30_0 BL_30 BL__30 WL WL VDD VSS SIGN_MEMCCOP
XI30_1 BL__30 BL_30 WL WL VDD VSS SIGN_MEMCCOP
XI31_0 BL_31 BL__31 WL WL VDD VSS SIGN_MEMCCEG
XI31_1 BL__31 BL_31 WL WL VDD VSS SIGN_MEMCCEG
XI32_0 NDL_8 NDR_6 WL VDD VSS SIGN_MEMFLCCSTRAP
XI32_1 NDL_8 NDR_6 WL VDD VSS SIGN_MEMFLCCSTRAP
XI33_0 BL_32 BL__32 WL WL VDD VSS SIGN_MEMCCOG
XI33_1 BL__32 BL_32 WL WL VDD VSS SIGN_MEMCCOG
XI34_0 BL_33 BL__33 WL WL VDD VSS SIGN_MEMCCEP
XI34_1 BL__33 BL_33 WL WL VDD VSS SIGN_MEMCCEP
XI35_0 BL_34 BL__34 WL WL VDD VSS SIGN_MEMCCOP
XI35_1 BL__34 BL_34 WL WL VDD VSS SIGN_MEMCCOP
XI36_0 BL_35 BL__35 WL WL VDD VSS SIGN_MEMCCEG
XI36_1 BL__35 BL_35 WL WL VDD VSS SIGN_MEMCCEG
XI37_0 BL_36 BL__36 WL WL VDD VSS SIGN_MEMCCOG
XI37_1 BL__36 BL_36 WL WL VDD VSS SIGN_MEMCCOG
XI38_0 BL_37 BL__37 WL WL VDD VSS SIGN_MEMCCEP
XI38_1 BL__37 BL_37 WL WL VDD VSS SIGN_MEMCCEP
XI39_0 BL_38 BL__38 WL WL VDD VSS SIGN_MEMCCOP
XI39_1 BL__38 BL_38 WL WL VDD VSS SIGN_MEMCCOP
XI3_0 BL_3 BL__3 WL WL VDD VSS SIGN_MEMCCEG
XI3_1 BL__3 BL_3 WL WL VDD VSS SIGN_MEMCCEG
XI40_0 BL_39 BL__39 WL WL VDD VSS SIGN_MEMCCEG
XI40_1 BL__39 BL_39 WL WL VDD VSS SIGN_MEMCCEG
XI41_0 BL_40 BL__40 WL WL VDD VSS SIGN_MEMCCOG
XI41_1 BL__40 BL_40 WL WL VDD VSS SIGN_MEMCCOG
XI42_0 BL_41 BL__41 WL WL VDD VSS SIGN_MEMCCEP
XI42_1 BL__41 BL_41 WL WL VDD VSS SIGN_MEMCCEP
XI43_0 BL_42 BL__42 WL WL VDD VSS SIGN_MEMCCOP
XI43_1 BL__42 BL_42 WL WL VDD VSS SIGN_MEMCCOP
XI44_0 BL_43 BL__43 WL WL VDD VSS SIGN_MEMCCEG
XI44_1 BL__43 BL_43 WL WL VDD VSS SIGN_MEMCCEG
XI45_0 BL_44 BL__44 WL WL VDD VSS SIGN_MEMCCOG
XI45_1 BL__44 BL_44 WL WL VDD VSS SIGN_MEMCCOG
XI46_0 BL_45 BL__45 WL WL VDD VSS SIGN_MEMCCEP
XI46_1 BL__45 BL_45 WL WL VDD VSS SIGN_MEMCCEP
XI47_0 BL_46 BL__46 WL WL VDD VSS SIGN_MEMCCOP
XI47_1 BL__46 BL_46 WL WL VDD VSS SIGN_MEMCCOP
XI48_0 BL_47 BL__47 WL WL VDD VSS SIGN_MEMCCEG
XI48_1 BL__47 BL_47 WL WL VDD VSS SIGN_MEMCCEG
XI49_0 BL_48 BL__48 WL WL VDD VSS SIGN_MEMCCOG
XI49_1 BL__48 BL_48 WL WL VDD VSS SIGN_MEMCCOG
XI4_0 BL_4 BL__4 WL WL VDD VSS SIGN_MEMCCOG
XI4_1 BL__4 BL_4 WL WL VDD VSS SIGN_MEMCCOG
XI50_0 BL_49 BL__49 WL WL VDD VSS SIGN_MEMCCEP
XI50_1 BL__49 BL_49 WL WL VDD VSS SIGN_MEMCCEP
XI51_0 BL_50 BL__50 WL WL VDD VSS SIGN_MEMCCOP
XI51_1 BL__50 BL_50 WL WL VDD VSS SIGN_MEMCCOP
XI52_0 BL_51 BL__51 WL WL VDD VSS SIGN_MEMCCEG
XI52_1 BL__51 BL_51 WL WL VDD VSS SIGN_MEMCCEG
XI53_0 BL_52 BL__52 WL WL VDD VSS SIGN_MEMCCOG
XI53_1 BL__52 BL_52 WL WL VDD VSS SIGN_MEMCCOG
XI54_0 BL_53 BL__53 WL WL VDD VSS SIGN_MEMCCEP
XI54_1 BL__53 BL_53 WL WL VDD VSS SIGN_MEMCCEP
XI55_0 BL_54 BL__54 WL WL VDD VSS SIGN_MEMCCOP
XI55_1 BL__54 BL_54 WL WL VDD VSS SIGN_MEMCCOP
XI56_0 BL_55 BL__55 WL WL VDD VSS SIGN_MEMCCEG
XI56_1 BL__55 BL_55 WL WL VDD VSS SIGN_MEMCCEG
XI57_0 BL_56 BL__56 WL WL VDD VSS SIGN_MEMCCOG
XI57_1 BL__56 BL_56 WL WL VDD VSS SIGN_MEMCCOG
XI58_0 BL_57 BL__57 WL WL VDD VSS SIGN_MEMCCEP
XI58_1 BL__57 BL_57 WL WL VDD VSS SIGN_MEMCCEP
XI59_0 BL_58 BL__58 WL WL VDD VSS SIGN_MEMCCOP
XI59_1 BL__58 BL_58 WL WL VDD VSS SIGN_MEMCCOP
XI5_0 BL_5 BL__5 WL WL VDD VSS SIGN_MEMCCEP
XI5_1 BL__5 BL_5 WL WL VDD VSS SIGN_MEMCCEP
XI60_0 BL_59 BL__59 WL WL VDD VSS SIGN_MEMCCEG
XI60_1 BL__59 BL_59 WL WL VDD VSS SIGN_MEMCCEG
XI61_0 BL_60 BL__60 WL WL VDD VSS SIGN_MEMCCOG
XI61_1 BL__60 BL_60 WL WL VDD VSS SIGN_MEMCCOG
XI62_0 BL_61 BL__61 WL WL VDD VSS SIGN_MEMCCEP
XI62_1 BL__61 BL_61 WL WL VDD VSS SIGN_MEMCCEP
XI63_0 BL_62 BL__62 WL WL VDD VSS SIGN_MEMCCOP
XI63_1 BL__62 BL_62 WL WL VDD VSS SIGN_MEMCCOP
XI64_0 BL_63 BL__63 WL WL VDD VSS SIGN_MEMCCEG
XI64_1 BL__63 BL_63 WL WL VDD VSS SIGN_MEMCCEG
XI65_0 NDL_4 NDR_2 WL VDD VSS SIGN_MEMFLCCSTRAP
XI65_1 NDL_4 NDR_2 WL VDD VSS SIGN_MEMFLCCSTRAP
XI66_0 BL0 BL0_ BL1 BL1_ WL WL WL VSS VSS VDD VSS SIGN_MEMFLMWOG
XI68_0 BL_64 BL__64 VSS VSS VDD VSS SIGN_MEMCCOP
XI68_1 BL__64 BL_64 VSS VSS VDD VSS SIGN_MEMCCOP
XI69_0 BL_65 BL__65 VSS VSS VDD VSS SIGN_MEMCCEG
XI69_1 BL__65 BL_65 VSS VSS VDD VSS SIGN_MEMCCEG
XI6_0 BL_6 BL__6 WL WL VDD VSS SIGN_MEMCCOP
XI6_1 BL__6 BL_6 WL WL VDD VSS SIGN_MEMCCOP
XI70_0 BL_66 BL__66 VSS VSS VDD VSS SIGN_MEMCCOG
XI70_1 BL__66 BL_66 VSS VSS VDD VSS SIGN_MEMCCOG
XI71_0 BL_67 BL__67 VSS VSS VDD VSS SIGN_MEMCCEP
XI71_1 BL__67 BL_67 VSS VSS VDD VSS SIGN_MEMCCEP
XI72_0 BL_68 BL__68 VSS VSS VDD VSS SIGN_MEMCCOP
XI72_1 BL__68 BL_68 VSS VSS VDD VSS SIGN_MEMCCOP
XI73_0 BL_69 BL__69 VSS VSS VDD VSS SIGN_MEMCCEG
XI73_1 BL__69 BL_69 VSS VSS VDD VSS SIGN_MEMCCEG
XI74_0 BL_70 BL__70 VSS VSS VDD VSS SIGN_MEMCCOG
XI74_1 BL__70 BL_70 VSS VSS VDD VSS SIGN_MEMCCOG
XI75_0 BL_71 BL__71 VSS VSS VDD VSS SIGN_MEMCCEP
XI75_1 BL__71 BL_71 VSS VSS VDD VSS SIGN_MEMCCEP
XI76_0 BL_72 BL__72 VSS VSS VDD VSS SIGN_MEMCCOP
XI76_1 BL__72 BL_72 VSS VSS VDD VSS SIGN_MEMCCOP
XI77_0 BL_73 BL__73 VSS VSS VDD VSS SIGN_MEMCCEG
XI77_1 BL__73 BL_73 VSS VSS VDD VSS SIGN_MEMCCEG
XI78_0 BL_74 BL__74 VSS VSS VDD VSS SIGN_MEMCCOG
XI78_1 BL__74 BL_74 VSS VSS VDD VSS SIGN_MEMCCOG
XI79_0 BL_75 BL__75 VSS VSS VDD VSS SIGN_MEMCCEP
XI79_1 BL__75 BL_75 VSS VSS VDD VSS SIGN_MEMCCEP
XI7_0 BL_7 BL__7 WL WL VDD VSS SIGN_MEMCCEG
XI7_1 BL__7 BL_7 WL WL VDD VSS SIGN_MEMCCEG
XI80_0 BL_76 BL__76 VSS VSS VDD VSS SIGN_MEMCCOP
XI80_1 BL__76 BL_76 VSS VSS VDD VSS SIGN_MEMCCOP
XI81_0 BL_77 BL__77 VSS VSS VDD VSS SIGN_MEMCCEG
XI81_1 BL__77 BL_77 VSS VSS VDD VSS SIGN_MEMCCEG
XI82_0 BL_78 BL__78 VSS VSS VDD VSS SIGN_MEMCCOG
XI82_1 BL__78 BL_78 VSS VSS VDD VSS SIGN_MEMCCOG
XI83_0 BL_79 BL__79 VSS VSS VDD VSS SIGN_MEMCCEP
XI83_1 BL__79 BL_79 VSS VSS VDD VSS SIGN_MEMCCEP
XI84_0 BL_80 BL__80 VSS VSS VDD VSS SIGN_MEMCCOP
XI84_1 BL__80 BL_80 VSS VSS VDD VSS SIGN_MEMCCOP
XI85_0 BL_81 BL__81 VSS VSS VDD VSS SIGN_MEMCCEG
XI85_1 BL__81 BL_81 VSS VSS VDD VSS SIGN_MEMCCEG
XI86_0 BL_82 BL__82 VSS VSS VDD VSS SIGN_MEMCCOG
XI86_1 BL__82 BL_82 VSS VSS VDD VSS SIGN_MEMCCOG
XI87_0 BL_83 BL__83 VSS VSS VDD VSS SIGN_MEMCCEP
XI87_1 BL__83 BL_83 VSS VSS VDD VSS SIGN_MEMCCEP
XI88_0 BL_84 BL__84 VSS VSS VDD VSS SIGN_MEMCCOP
XI88_1 BL__84 BL_84 VSS VSS VDD VSS SIGN_MEMCCOP
XI89_0 BL_85 BL__85 VSS VSS VDD VSS SIGN_MEMCCEG
XI89_1 BL__85 BL_85 VSS VSS VDD VSS SIGN_MEMCCEG
XI8_0 BL_8 BL__8 WL WL VDD VSS SIGN_MEMCCOG
XI8_1 BL__8 BL_8 WL WL VDD VSS SIGN_MEMCCOG
XI90_0 BL_86 BL__86 VSS VSS VDD VSS SIGN_MEMCCOG
XI90_1 BL__86 BL_86 VSS VSS VDD VSS SIGN_MEMCCOG
XI91_0 BL_87 BL__87 VSS VSS VDD VSS SIGN_MEMCCEP
XI91_1 BL__87 BL_87 VSS VSS VDD VSS SIGN_MEMCCEP
XI92_0 BL_88 BL__88 VSS VSS VDD VSS SIGN_MEMCCOP
XI92_1 BL__88 BL_88 VSS VSS VDD VSS SIGN_MEMCCOP
XI93_0 BL_89 BL__89 VSS VSS VDD VSS SIGN_MEMCCEG
XI93_1 BL__89 BL_89 VSS VSS VDD VSS SIGN_MEMCCEG
XI94_0 BL_90 BL__90 VSS VSS VDD VSS SIGN_MEMCCOG
XI94_1 BL__90 BL_90 VSS VSS VDD VSS SIGN_MEMCCOG
XI95_0 BL_91 BL__91 VSS VSS VDD VSS SIGN_MEMCCEP
XI95_1 BL__91 BL_91 VSS VSS VDD VSS SIGN_MEMCCEP
XI96_0 BL_92 BL__92 VSS VSS VDD VSS SIGN_MEMCCOP
XI96_1 BL__92 BL_92 VSS VSS VDD VSS SIGN_MEMCCOP
XI97_0 BL_93 BL__93 VSS VSS VDD VSS SIGN_MEMCCEG
XI97_1 BL__93 BL_93 VSS VSS VDD VSS SIGN_MEMCCEG
XI98_0 NDL NDR VSS VDD VSS SIGN_MEMFLCCSTRAP
XI98_1 NDL NDR VSS VDD VSS SIGN_MEMFLCCSTRAP
XI99_0 BL_94 BL__94 VSS VSS VDD VSS SIGN_MEMCCOG
XI99_1 BL__94 BL_94 VSS VSS VDD VSS SIGN_MEMCCOG
XI9_0 BL_9 BL__9 WL WL VDD VSS SIGN_MEMCCEP
XI9_1 BL__9 BL_9 WL WL VDD VSS SIGN_MEMCCEP
.ENDS SIGN_MEMMROW_8_LEFT
****
.SUBCKT SIGN_MEMWD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMWD: 30 flat devices **
m1 N25 RSWN0 GTP VDD LPPFET L=0.12U W=0.9U
m10 WL0 WL0_EN_ VSS VSS LPNFET L=0.12U W=12.54U
m11 N24 RSWN1 GTP VDD LPPFET L=0.12U W=0.9U
m12 N24 WLI1 GTP VSS LPNFET L=0.12U W=0.9U
m13 N33 G0 VSS VSS LPNFET L=0.12U W=0.88U
m14 N34 G1 N33 VSS LPNFET L=0.12U W=0.88U
m15 RSWN1 G2_W1 N34 VSS LPNFET L=0.12U W=0.88U
m16 RSWN1 G0 VDD VDD LPPFET L=0.12U W=0.68U
m17 RSWN1 G2_W1 VDD VDD LPPFET L=0.12U W=0.68U
m18 RSWN1 G1 VDD VDD LPPFET L=0.12U W=0.68U
m19 WL1 WL1_EN_ VDD VDD LPPFET L=0.12U W=22.74U
m2 N25 WLI0 GTP VSS LPNFET L=0.12U W=0.9U
m20 WL1 WL1_EN_ VSS VSS LPNFET L=0.12U W=12.54U
m21 WLI1 RSWN1 VDD VDD LPPFET L=0.12U W=0.46U
m22 WLI1 RSWN1 VSS VSS LPNFET L=0.12U W=0.24U
m23 WLI0 RSWN0 VDD VDD LPPFET L=0.12U W=0.46U
m24 WLI0 RSWN0 VSS VSS LPNFET L=0.12U W=0.24U
m25 N24 RSWN1 VSS VSS LPNFET L=0.12U W=0.28U
m26 N25 RSWN0 VSS VSS LPNFET L=0.12U W=0.28U
m27 WL1_EN_ N24 VDD VDD LPPFET L=0.12U W=10.56U
m28 WL1_EN_ N24 VSS VSS LPNFET L=0.12U W=5.04U
m29 WL0_EN_ N25 VDD VDD LPPFET L=0.12U W=10.56U
m3 N26 G0 VSS VSS LPNFET L=0.12U W=0.88U
m30 WL0_EN_ N25 VSS VSS LPNFET L=0.12U W=5.04U
m4 N27 G1 N26 VSS LPNFET L=0.12U W=0.88U
m5 RSWN0 G2_W0 N27 VSS LPNFET L=0.12U W=0.88U
m6 RSWN0 G0 VDD VDD LPPFET L=0.12U W=0.68U
m7 RSWN0 G2_W0 VDD VDD LPPFET L=0.12U W=0.68U
m8 RSWN0 G1 VDD VDD LPPFET L=0.12U W=0.68U
m9 WL0 WL0_EN_ VDD VDD LPPFET L=0.12U W=22.74U
.ENDS SIGN_MEMWD
****
.SUBCKT SIGN_MEMWD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMWD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMWD
.ENDS SIGN_MEMWD3
****
.SUBCKT SIGN_MEMROW_FILLER3 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2 XP0_3
+  XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_FILLER3: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMWD3
.ENDS SIGN_MEMROW_FILLER3
****
.SUBCKT SIGN_MEMWD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMWD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMWD
.ENDS SIGN_MEMWD0
****
.SUBCKT SIGN_MEMROW_8 G0 G1 G1B GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2 XP0F_3 XP0_0
+  XP0_1 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_8: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMWD0
.ENDS SIGN_MEMROW_8
****
.SUBCKT SIGN_MEMWD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMWD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMWD
.ENDS SIGN_MEMWD1
****
.SUBCKT SIGN_MEMROW_FILLER1 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2 XP0_3
+  XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_FILLER1: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMWD1
.ENDS SIGN_MEMROW_FILLER1
****
.SUBCKT SIGN_MEMWD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMWD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMWD
.ENDS SIGN_MEMWD2
****
.SUBCKT SIGN_MEMROW_FILLER2 G0 G1 GTP WL0 WL1 XP0F XP0_0 XP0_1 XP0_2 XP0_3
+  XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_FILLER2: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMWD2
.ENDS SIGN_MEMROW_FILLER2
****
.SUBCKT SIGN_MEMFCMWDX MWL XP0 XP1 VDD VSS
** SIGN_MEMFCMWDX: 2 flat devices **
d1 VSS XP1 tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS XP0 tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCMWDX
****
.SUBCKT SIGN_MEMFCMWD G0F G1F MWL XP0F XP1F VDD VSS
** SIGN_MEMFCMWD: 2 flat devices **
d1 VSS XP1F tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS XP0F tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCMWD
****
.SUBCKT SIGN_MEMMWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7 MWG8
+  MWG9 MWG10 MWG11 MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VDD VSS
** SIGN_MEMMWD: 41 flat devices **
m1 MWL N58 VDD VDD LPPFET L=0.12U W=22.74U
m10 MBL MWG1 VSS VSS LPNFET L=0.56U W=0.21U
m11 MBL MWG0 VSS VSS LPNFET L=0.56U W=0.21U
m12 MBL MWG3 VSS VSS LPNFET L=0.56U W=0.21U
m13 MBL MWG2 VSS VSS LPNFET L=0.56U W=0.21U
m14 MBL MWG3 VSS VSS LPNFET L=0.56U W=0.21U
m15 MBL MWG2 VSS VSS LPNFET L=0.56U W=0.21U
m16 MBL MWG5 VSS VSS LPNFET L=0.56U W=0.21U
m17 MBL MWG4 VSS VSS LPNFET L=0.56U W=0.21U
m18 MBL MWG5 VSS VSS LPNFET L=0.56U W=0.21U
m19 MBL MWG4 VSS VSS LPNFET L=0.56U W=0.21U
m2 MWL N58 VSS VSS LPNFET L=0.12U W=12.54U
m20 MBL MWG7 VSS VSS LPNFET L=0.56U W=0.21U
m21 MBL MWG6 VSS VSS LPNFET L=0.56U W=0.21U
m22 MBL MWG7 VSS VSS LPNFET L=0.56U W=0.21U
m23 MBL MWG6 VSS VSS LPNFET L=0.56U W=0.21U
m24 MBL MWG9 VSS VSS LPNFET L=0.56U W=0.21U
m25 MBL MWG8 VSS VSS LPNFET L=0.56U W=0.21U
m26 MBL MWG9 VSS VSS LPNFET L=0.56U W=0.21U
m27 MBL MWG8 VSS VSS LPNFET L=0.56U W=0.21U
m28 MBL MWG11 VSS VSS LPNFET L=0.56U W=0.21U
m29 MBL MWG10 VSS VSS LPNFET L=0.56U W=0.21U
m3 MBL GTP VDD VDD LPPFET L=0.12U W=6.5U
m30 MBL MWG11 VSS VSS LPNFET L=0.56U W=0.21U
m31 MBL MWG10 VSS VSS LPNFET L=0.56U W=0.21U
m32 MBL MWLD VSS VSS LPNFET L=0.56U W=0.16U
m33 MBL MWLD VSS VSS LPNFET L=0.56U W=0.16U
m34 MBL MWLD VSS VSS LPNFET L=0.56U W=0.16U
m35 MBL MWLD VSS VSS LPNFET L=0.56U W=0.16U
m36 N58 N57 VDD VDD LPPFET L=0.12U W=10.56U
m37 N58 N57 VSS VSS LPNFET L=0.12U W=5.04U
m4 MBL_ GTP VDD VDD LPPFET L=0.12U W=6.5U
m40 N57 N65 VDD VDD LPPFET L=0.16U W=0.46U
m41 N57 N65 VSS VSS LPNFET L=0.16U W=0.28U
m42 N65 N64 VDD VDD LPPFET L=0.16U W=0.46U
m43 N65 N64 VSS VSS LPNFET L=0.16U W=0.28U
m5 MBL GTP MBL_ VDD LPPFET L=0.12U W=6.5U
m6 N64 VSS GTP VDD LPPFET L=0.24U W=0.7U
m7 N64 VDD GTP VSS LPNFET L=0.24U W=0.7U
m8 MBL MWG1 VSS VSS LPNFET L=0.56U W=0.21U
m9 MBL MWG0 VSS VSS LPNFET L=0.56U W=0.21U
.ENDS SIGN_MEMMWD
****
.SUBCKT SIGN_MEMMWDX GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMMWDX: 41 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS MWL
+  MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMMWD
.ENDS SIGN_MEMMWDX
****
.SUBCKT SIGN_MEMROW_TOP G0F G1F GTP MBL MBL_ MWL MWLD XP0F XP0_0 XP0_1 XP0_2
+  XP0_3 XP0_4 XP1F XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_TOP: 53 flat devices **
XI0_0 MWL XP0_0 XP1_0 VDD VSS SIGN_MEMFCMWDX
XI1_0 MWL XP0_1 XP1_1 VDD VSS SIGN_MEMFCMWDX
XI2_0 MWL XP0_2 XP1_2 VDD VSS SIGN_MEMFCMWDX
XI3_0 MWL XP0_3 XP1_3 VDD VSS SIGN_MEMFCMWDX
XI4_0 MWL XP0_4 XP1_4 VDD VSS SIGN_MEMFCMWDX
XI5_0 G0F G1F MWL XP0F XP1F VDD VSS SIGN_MEMFCMWD
XI6_0 GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VDD VSS SIGN_MEMMWDX
.ENDS SIGN_MEMROW_TOP
****
.SUBCKT SIGN_MEMROW_64 G0 G0B G1 G1B GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2 XP0F_3
+  XP0F_4 XP0F_5 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP1F_5 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_64: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMWD0
.ENDS SIGN_MEMROW_64
****
.SUBCKT SIGN_MEMHWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMHWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD LPPFET L=0.12U W=0.9U
m10 WL0 WD_I0-WL0_EN_ VSS VSS LPNFET L=0.12U W=12.54U
m11 N24 WD_I0-RSWN1 GTP VDD LPPFET L=0.12U W=0.9U
m12 N24 WD_I0-WLI1 GTP VSS LPNFET L=0.12U W=0.9U
m13 N33 G0 VSS VSS LPNFET L=0.12U W=0.88U
m14 N34 G1 N33 VSS LPNFET L=0.12U W=0.88U
m15 WD_I0-RSWN1 G2_W1 N34 VSS LPNFET L=0.12U W=0.88U
m16 WD_I0-RSWN1 G0 VDD VDD LPPFET L=0.12U W=0.68U
m17 WD_I0-RSWN1 G2_W1 VDD VDD LPPFET L=0.12U W=0.68U
m18 WD_I0-RSWN1 G1 VDD VDD LPPFET L=0.12U W=0.68U
m19 WL1 WD_I0-WL1_EN_ VDD VDD LPPFET L=0.12U W=22.74U
m2 N25 WD_I0-WLI0 GTP VSS LPNFET L=0.12U W=0.9U
m20 WL1 WD_I0-WL1_EN_ VSS VSS LPNFET L=0.12U W=12.54U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD LPPFET L=0.12U W=0.46U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS LPNFET L=0.12U W=0.24U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD LPPFET L=0.12U W=0.46U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS LPNFET L=0.12U W=0.24U
m25 N24 WD_I0-RSWN1 VSS VSS LPNFET L=0.12U W=0.28U
m26 N25 WD_I0-RSWN0 VSS VSS LPNFET L=0.12U W=0.28U
m27 WD_I0-WL1_EN_ N24 VDD VDD LPPFET L=0.12U W=10.56U
m28 WD_I0-WL1_EN_ N24 VSS VSS LPNFET L=0.12U W=5.04U
m29 WD_I0-WL0_EN_ N25 VDD VDD LPPFET L=0.12U W=10.56U
m3 N26 G0 VSS VSS LPNFET L=0.12U W=0.88U
m30 WD_I0-WL0_EN_ N25 VSS VSS LPNFET L=0.12U W=5.04U
m4 N27 G1 N26 VSS LPNFET L=0.12U W=0.88U
m5 WD_I0-RSWN0 G2_W0 N27 VSS LPNFET L=0.12U W=0.88U
m6 WD_I0-RSWN0 G0 VDD VDD LPPFET L=0.12U W=0.68U
m7 WD_I0-RSWN0 G2_W0 VDD VDD LPPFET L=0.12U W=0.68U
m8 WD_I0-RSWN0 G1 VDD VDD LPPFET L=0.12U W=0.68U
m9 WL0 WD_I0-WL0_EN_ VDD VDD LPPFET L=0.12U W=22.74U
.ENDS SIGN_MEMHWDB
****
.SUBCKT SIGN_MEMHWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS
** SIGN_MEMHWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMHWDB
.ENDS SIGN_MEMHWDB0
****
.SUBCKT SIGN_MEMROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F_0 XP0F_1 XP0F_2 XP0F_3
+  XP0F_4 XP0F_5 XP1F_0 XP1F_1 XP1F_2 XP1F_3 XP1F_4 XP1F_5 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD VSS
** SIGN_MEMROW_BOTTOM: 30 flat devices **
XI6_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS SIGN_MEMHWDB0
.ENDS SIGN_MEMROW_BOTTOM
****
.SUBCKT SIGN_MEMWORD_ROWS GTP MBL MBL_ MWL MWLD WL0_0 WL0_1 WL0_2 WL0_3 WL0_4
+  WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL0_15
+  WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23 WL0_24 WL0_25
+  WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL0_31 WL0_32 WL0_33 WL0_34 WL0_35
+  WL0_36 WL0_37 WL0_38 WL0_39 WL0_40 WL0_41 WL0_42 WL0_43 WL0_44 WL0_45
+  WL0_46 WL0_47 WL0_48 WL0_49 WL0_50 WL0_51 WL0_52 WL0_53 WL0_54 WL0_55
+  WL0_56 WL0_57 WL0_58 WL0_59 WL0_60 WL0_61 WL0_62 WL0_63 WL0_64 WL0_65
+  WL0_66 WL0_67 WL0_68 WL0_69 WL0_70 WL0_71 WL0_72 WL0_73 WL0_74 WL0_75
+  WL0_76 WL0_77 WL0_78 WL0_79 WL0_80 WL0_81 WL0_82 WL0_83 WL0_84 WL0_85
+  WL0_86 WL0_87 WL0_88 WL0_89 WL0_90 WL0_91 WL0_92 WL0_93 WL0_94 WL0_95
+  WL0_96 WL0_97 WL0_98 WL0_99 WL0_100 WL0_101 WL0_102 WL0_103 WL0_104 WL0_105
+  WL0_106 WL0_107 WL0_108 WL0_109 WL0_110 WL0_111 WL0_112 WL0_113 WL0_114
+  WL0_115 WL0_116 WL0_117 WL0_118 WL0_119 WL0_120 WL0_121 WL0_122 WL0_123
+  WL0_124 WL0_125 WL0_126 WL0_127 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6
+  WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 WL1_15 WL1_16 WL1_17
+  WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23 WL1_24 WL1_25 WL1_26 WL1_27
+  WL1_28 WL1_29 WL1_30 WL1_31 WL1_32 WL1_33 WL1_34 WL1_35 WL1_36 WL1_37
+  WL1_38 WL1_39 WL1_40 WL1_41 WL1_42 WL1_43 WL1_44 WL1_45 WL1_46 WL1_47
+  WL1_48 WL1_49 WL1_50 WL1_51 WL1_52 WL1_53 WL1_54 WL1_55 WL1_56 WL1_57
+  WL1_58 WL1_59 WL1_60 WL1_61 WL1_62 WL1_63 WL1_64 WL1_65 WL1_66 WL1_67
+  WL1_68 WL1_69 WL1_70 WL1_71 WL1_72 WL1_73 WL1_74 WL1_75 WL1_76 WL1_77
+  WL1_78 WL1_79 WL1_80 WL1_81 WL1_82 WL1_83 WL1_84 WL1_85 WL1_86 WL1_87
+  WL1_88 WL1_89 WL1_90 WL1_91 WL1_92 WL1_93 WL1_94 WL1_95 WL1_96 WL1_97
+  WL1_98 WL1_99 WL1_100 WL1_101 WL1_102 WL1_103 WL1_104 WL1_105 WL1_106
+  WL1_107 WL1_108 WL1_109 WL1_110 WL1_111 WL1_112 WL1_113 WL1_114 WL1_115
+  WL1_116 WL1_117 WL1_118 WL1_119 WL1_120 WL1_121 WL1_122 WL1_123 WL1_124
+  WL1_125 WL1_126 WL1_127 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP1_0 XP1_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VDD
+  VSS
** SIGN_MEMWORD_ROWS: 3893 flat devices **
XI0_0 XP0_1 XP0_5 GTP WL0_0 WL1_0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP1_0
+  XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_BOTTOM
XI0_1 XP0_1 XP0_5 GTP WL0_1 WL1_1 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_10 XP0_1 XP0_4 GTP WL0_10 WL1_10 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_100 XP1_0 XP1_5 XP0_5 GTP WL0_100 WL1_100 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_101 XP1_0 XP1_5 GTP WL0_101 WL1_101 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_102 XP1_0 XP1_5 GTP WL0_102 WL1_102 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_103 XP1_0 XP1_5 GTP WL0_103 WL1_103 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_104 XP1_0 XP0_4 XP1_5 GTP WL0_104 WL1_104 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_105 XP1_0 XP0_4 GTP WL0_105 WL1_105 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_106 XP1_0 XP0_4 GTP WL0_106 WL1_106 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_107 XP1_0 XP0_4 GTP WL0_107 WL1_107 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_108 XP1_0 XP1_4 XP0_4 GTP WL0_108 WL1_108 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_109 XP1_0 XP1_4 GTP WL0_109 WL1_109 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_11 XP0_1 XP0_4 GTP WL0_11 WL1_11 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_110 XP1_0 XP1_4 GTP WL0_110 WL1_110 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_111 XP1_0 XP1_4 GTP WL0_111 WL1_111 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_112 XP1_0 XP0_3 XP1_4 GTP WL0_112 WL1_112 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_113 XP1_0 XP0_3 GTP WL0_113 WL1_113 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_114 XP1_0 XP0_3 GTP WL0_114 WL1_114 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_115 XP1_0 XP0_3 GTP WL0_115 WL1_115 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_116 XP1_0 XP1_3 XP0_3 GTP WL0_116 WL1_116 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_117 XP1_0 XP1_3 GTP WL0_117 WL1_117 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_118 XP1_0 XP1_3 GTP WL0_118 WL1_118 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_119 XP1_0 XP1_3 GTP WL0_119 WL1_119 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_12 XP0_1 XP1_4 XP0_4 GTP WL0_12 WL1_12 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_120 XP1_0 XP0_2 XP1_3 GTP WL0_120 WL1_120 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_121 XP1_0 XP0_2 GTP WL0_121 WL1_121 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_122 XP1_0 XP0_2 GTP WL0_122 WL1_122 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_123 XP1_0 XP0_2 GTP WL0_123 WL1_123 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_124 XP1_0 XP1_2 XP0_2 GTP WL0_124 WL1_124 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0
+  XP0_1 XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_125 XP1_0 XP1_2 GTP WL0_125 WL1_125 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_126 XP1_0 XP1_2 GTP WL0_126 WL1_126 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_127 XP1_0 XP1_2 GTP WL0_127 WL1_127 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_128 XP1_0 XP1_2 GTP MBL MBL_ MWL MWLD XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP1_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_TOP
XI0_13 XP0_1 XP1_4 GTP WL0_13 WL1_13 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_14 XP0_1 XP1_4 GTP WL0_14 WL1_14 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_15 XP0_1 XP1_4 GTP WL0_15 WL1_15 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_16 XP0_1 XP0_3 XP1_4 GTP WL0_16 WL1_16 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_17 XP0_1 XP0_3 GTP WL0_17 WL1_17 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_18 XP0_1 XP0_3 GTP WL0_18 WL1_18 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_19 XP0_1 XP0_3 GTP WL0_19 WL1_19 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_2 XP0_1 XP0_5 GTP WL0_2 WL1_2 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_20 XP0_1 XP1_3 XP0_3 GTP WL0_20 WL1_20 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_21 XP0_1 XP1_3 GTP WL0_21 WL1_21 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_22 XP0_1 XP1_3 GTP WL0_22 WL1_22 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_23 XP0_1 XP1_3 GTP WL0_23 WL1_23 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_24 XP0_1 XP0_2 XP1_3 GTP WL0_24 WL1_24 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_25 XP0_1 XP0_2 GTP WL0_25 WL1_25 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_26 XP0_1 XP0_2 GTP WL0_26 WL1_26 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_27 XP0_1 XP0_2 GTP WL0_27 WL1_27 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_28 XP0_1 XP1_2 XP0_2 GTP WL0_28 WL1_28 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_29 XP0_1 XP1_2 GTP WL0_29 WL1_29 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_3 XP0_1 XP0_5 GTP WL0_3 WL1_3 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_30 XP0_1 XP1_2 GTP WL0_30 WL1_30 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_31 XP0_1 XP1_2 GTP WL0_31 WL1_31 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_32 XP1_1 XP0_1 XP0_5 XP1_2 GTP WL0_32 WL1_32 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_64
XI0_33 XP1_1 XP0_5 GTP WL0_33 WL1_33 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_34 XP1_1 XP0_5 GTP WL0_34 WL1_34 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_35 XP1_1 XP0_5 GTP WL0_35 WL1_35 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_36 XP1_1 XP1_5 XP0_5 GTP WL0_36 WL1_36 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_37 XP1_1 XP1_5 GTP WL0_37 WL1_37 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_38 XP1_1 XP1_5 GTP WL0_38 WL1_38 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_39 XP1_1 XP1_5 GTP WL0_39 WL1_39 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_4 XP0_1 XP1_5 XP0_5 GTP WL0_4 WL1_4 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_40 XP1_1 XP0_4 XP1_5 GTP WL0_40 WL1_40 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_41 XP1_1 XP0_4 GTP WL0_41 WL1_41 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_42 XP1_1 XP0_4 GTP WL0_42 WL1_42 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_43 XP1_1 XP0_4 GTP WL0_43 WL1_43 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_44 XP1_1 XP1_4 XP0_4 GTP WL0_44 WL1_44 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_45 XP1_1 XP1_4 GTP WL0_45 WL1_45 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_46 XP1_1 XP1_4 GTP WL0_46 WL1_46 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_47 XP1_1 XP1_4 GTP WL0_47 WL1_47 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_48 XP1_1 XP0_3 XP1_4 GTP WL0_48 WL1_48 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_49 XP1_1 XP0_3 GTP WL0_49 WL1_49 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_5 XP0_1 XP1_5 GTP WL0_5 WL1_5 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_50 XP1_1 XP0_3 GTP WL0_50 WL1_50 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_51 XP1_1 XP0_3 GTP WL0_51 WL1_51 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_52 XP1_1 XP1_3 XP0_3 GTP WL0_52 WL1_52 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_53 XP1_1 XP1_3 GTP WL0_53 WL1_53 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_54 XP1_1 XP1_3 GTP WL0_54 WL1_54 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_55 XP1_1 XP1_3 GTP WL0_55 WL1_55 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_56 XP1_1 XP0_2 XP1_3 GTP WL0_56 WL1_56 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_57 XP1_1 XP0_2 GTP WL0_57 WL1_57 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_58 XP1_1 XP0_2 GTP WL0_58 WL1_58 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_59 XP1_1 XP0_2 GTP WL0_59 WL1_59 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_6 XP0_1 XP1_5 GTP WL0_6 WL1_6 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_60 XP1_1 XP1_2 XP0_2 GTP WL0_60 WL1_60 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_61 XP1_1 XP1_2 GTP WL0_61 WL1_61 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_62 XP1_1 XP1_2 GTP WL0_62 WL1_62 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_63 XP1_1 XP1_2 GTP WL0_63 WL1_63 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_64 XP0_0 XP1_1 XP0_5 XP1_2 GTP WL0_64 WL1_64 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_64
XI0_65 XP0_0 XP0_5 GTP WL0_65 WL1_65 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_66 XP0_0 XP0_5 GTP WL0_66 WL1_66 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_67 XP0_0 XP0_5 GTP WL0_67 WL1_67 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_68 XP0_0 XP1_5 XP0_5 GTP WL0_68 WL1_68 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_69 XP0_0 XP1_5 GTP WL0_69 WL1_69 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_7 XP0_1 XP1_5 GTP WL0_7 WL1_7 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_70 XP0_0 XP1_5 GTP WL0_70 WL1_70 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_71 XP0_0 XP1_5 GTP WL0_71 WL1_71 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_72 XP0_0 XP0_4 XP1_5 GTP WL0_72 WL1_72 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_73 XP0_0 XP0_4 GTP WL0_73 WL1_73 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_74 XP0_0 XP0_4 GTP WL0_74 WL1_74 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_75 XP0_0 XP0_4 GTP WL0_75 WL1_75 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_76 XP0_0 XP1_4 XP0_4 GTP WL0_76 WL1_76 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_77 XP0_0 XP1_4 GTP WL0_77 WL1_77 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_78 XP0_0 XP1_4 GTP WL0_78 WL1_78 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_79 XP0_0 XP1_4 GTP WL0_79 WL1_79 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_8 XP0_1 XP0_4 XP1_5 GTP WL0_8 WL1_8 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_80 XP0_0 XP0_3 XP1_4 GTP WL0_80 WL1_80 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_81 XP0_0 XP0_3 GTP WL0_81 WL1_81 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_82 XP0_0 XP0_3 GTP WL0_82 WL1_82 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_83 XP0_0 XP0_3 GTP WL0_83 WL1_83 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_84 XP0_0 XP1_3 XP0_3 GTP WL0_84 WL1_84 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_85 XP0_0 XP1_3 GTP WL0_85 WL1_85 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_86 XP0_0 XP1_3 GTP WL0_86 WL1_86 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_87 XP0_0 XP1_3 GTP WL0_87 WL1_87 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_88 XP0_0 XP0_2 XP1_3 GTP WL0_88 WL1_88 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_89 XP0_0 XP0_2 GTP WL0_89 WL1_89 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_9 XP0_1 XP0_4 GTP WL0_9 WL1_9 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_90 XP0_0 XP0_2 GTP WL0_90 WL1_90 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_91 XP0_0 XP0_2 GTP WL0_91 WL1_91 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_92 XP0_0 XP1_2 XP0_2 GTP WL0_92 WL1_92 XP0_2 XP0_3 XP0_4 XP0_5 XP0_0 XP0_1
+  XP1_2 XP1_3 XP1_4 XP1_5 XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VDD VSS SIGN_MEMROW_8
XI0_93 XP0_0 XP1_2 GTP WL0_93 WL1_93 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_94 XP0_0 XP1_2 GTP WL0_94 WL1_94 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_95 XP0_0 XP1_2 GTP WL0_95 WL1_95 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
XI0_96 XP1_0 XP0_0 XP0_5 XP1_2 GTP WL0_96 WL1_96 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP1_5 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VDD VSS SIGN_MEMROW_64
XI0_97 XP1_0 XP0_5 GTP WL0_97 WL1_97 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER1
XI0_98 XP1_0 XP0_5 GTP WL0_98 WL1_98 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER2
XI0_99 XP1_0 XP0_5 GTP WL0_99 WL1_99 XP0_5 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP1_5
+  XP1_0 XP1_1 XP1_2 XP1_3 XP1_4 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VDD VSS SIGN_MEMROW_FILLER3
.ENDS SIGN_MEMWORD_ROWS
****
.SUBCKT SIGN_MEMHCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMHCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS LPNFET L=0.12U W=18.8U
m2 GTPN CLK CK-GTPFEED VSS LPNFET L=0.12U W=6.26U
m3 GTPN RST VDD VDD LPPFET L=0.12U W=12U
m4 AGTP GTPN VDD VDD LPPFET L=0.12U W=38U
m5 AGTP GTPN VSS VSS LPNFET L=0.12U W=11.2U
m6 CK-GTPNSRC GSRCN VDD VDD LPPFET L=0.12U W=2.12U
m7 CK-GTPNSRC GSRCN VSS VSS LPNFET L=0.12U W=1.6U
m8 CK-GTPFEED CLK CK-SRCFEED VSS LPNFET L=0.12U W=6.26U
m9 CK-GTPFEED GTPN VDD VSS LPNFET L=0.12U W=1.6U
.ENDS SIGN_MEMHCKA
****
.SUBCKT SIGN_MEMCK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMCK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS LPNFET L=0.12U W=18.8U
m2 GTPN CLK GTPFEED VSS LPNFET L=0.12U W=6.26U
m3 GTPN RST VDD VDD LPPFET L=0.12U W=12U
m4 GTP GTPN VDD VDD LPPFET L=0.12U W=38U
m5 GTP GTPN VSS VSS LPNFET L=0.12U W=11.2U
m6 GTPNSRC GSRCN VDD VDD LPPFET L=0.12U W=2.12U
m7 GTPNSRC GSRCN VSS VSS LPNFET L=0.12U W=1.6U
m8 GTPFEED CLK SRCFEED VSS LPNFET L=0.12U W=6.26U
m9 GTPFEED GTPN VDD VSS LPNFET L=0.12U W=1.6U
.ENDS SIGN_MEMCK
****
.SUBCKT SIGN_MEMCLK_DRVS A0 A0_ AGTP CLK GSRCN GTPN GTP_0 GTP_1 GTP_2 GTP_3
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMCLK_DRVS: 45 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VDD VSS SIGN_MEMHCKA
XI1_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMCK
XI2_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMCK
XI3_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMCK
XI4_0 A0 A0_ CLK GSRCN GTP_3 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMCK
.ENDS SIGN_MEMCLK_DRVS
****
.SUBCKT SIGN_MEMFCBWRO16 BWEN D Q VDD VSS
** SIGN_MEMFCBWRO16: 2 flat devices **
d1 VSS Q tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS D tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFCBWRO16
****
.SUBCKT SIGN_MEMMCOL_ODD_R16 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6
+  BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0 BLT__1
+  BLT__2 BLT__3 BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10 BLT__11
+  BLT__12 BLT__13 BLT__14 BLT__15 D GTP_0 GTP_1 GTP_2 OE_ Q STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 STUBWEI WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS
** SIGN_MEMMCOL_ODD_R16: 25025 flat devices **
XI0_0 VSS D Q VDD VSS SIGN_MEMFCBWRO16
XI0_1 GTP_0 OE_ STUBWEI VDD VSS SIGN_MEMFLIO
XI0_2 GTP_1 VDD VSS SIGN_MEMFLSA
XI0_3 A0 A0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS GTP_2 STUBDR_0 STUBDR_1
+  STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMUX_CD_ODD
XI0_5 BL0_7 BL1__7 BL1__6 BL0_6 BL0_5 BL1__5 BL1__4 BL0_4 BL0_3 BL1__3 BL1__2
+  BL0_2 BL0_1 BL1__1 BL1__0 BL0_0 BL0__7 BL1_7 BL1_6 BL0__6 BL0__5 BL1_5
+  BL1_4 BL0__4 BL0__3 BL1_3 BL1_2 BL0__2 BL0__1 BL1_1 BL1_0 BL0__0 WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63
+  WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75
+  WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87
+  WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99
+  WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 WP_63 WP_64 WP_65 WP_66
+  WP_67 WP_68 WP_69 WP_70 WP_71 WP_72 WP_73 WP_74 WP_75 WP_76 WP_77 WP_78
+  WP_79 WP_80 WP_81 WP_82 WP_83 WP_84 WP_85 WP_86 WP_87 WP_88 WP_89 WP_90
+  WP_91 WP_92 WP_93 WP_94 WP_95 WP_96 WP_97 WP_98 WP_99 WP_100 WP_101 WP_102
+  WP_103 WP_104 WP_105 WP_106 WP_107 WP_108 WP_109 WP_110 WP_111 WP_112
+  WP_113 WP_114 WP_115 WP_116 WP_117 WP_118 WP_119 WP_120 WP_121 WP_122
+  WP_123 WP_124 WP_125 WP_126 WP_127 WP_128 WP_129 WP_130 WP_131 WP_132
+  WP_133 WP_134 WP_135 WP_136 WP_137 WP_138 WP_139 WP_140 WP_141 WP_142
+  WP_143 WP_144 WP_145 WP_146 WP_147 WP_148 WP_149 WP_150 WP_151 WP_152
+  WP_153 WP_154 WP_155 WP_156 WP_157 WP_158 WP_159 WP_160 WP_161 WP_162
+  WP_163 WP_164 WP_165 WP_166 WP_167 WP_168 WP_169 WP_170 WP_171 WP_172
+  WP_173 WP_174 WP_175 WP_176 WP_177 WP_178 WP_179 WP_180 WP_181 WP_182
+  WP_183 WP_184 WP_185 WP_186 WP_187 WP_188 WP_189 WP_190 WP_191 WP_192
+  WP_193 WP_194 WP_195 WP_196 WP_197 WP_198 WP_199 WP_200 WP_201 WP_202
+  WP_203 WP_204 WP_205 WP_206 WP_207 WP_208 WP_209 WP_210 WP_211 WP_212
+  WP_213 WP_214 WP_215 WP_216 WP_217 WP_218 WP_219 WP_220 WP_221 WP_222
+  WP_223 WP_224 WP_225 WP_226 WP_227 WP_228 WP_229 WP_230 WP_231 WP_232
+  WP_233 WP_234 WP_235 WP_236 WP_237 WP_238 WP_239 WP_240 WP_241 WP_242
+  WP_243 WP_244 WP_245 WP_246 WP_247 WP_248 WP_249 WP_250 WP_251 WP_252
+  WP_253 WP_254 WP_255 VDD VSS SIGN_MEMBIT_COL
XI1_1 D DPN DPU STUBDW_0 STUBDW__0 GTP_0 OE_ Q SP STUBWEI VDD VSS SIGN_MEMIOX
XI1_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_1 SP VDD VSS
+  SIGN_MEMSA8
.ENDS SIGN_MEMMCOL_ODD_R16
****
.SUBCKT SIGN_MEMWING_8_RIGHT A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6
+  BLT_7 BLT_8 BLT_9 BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT_16 BLT_17
+  BLT_18 BLT_19 BLT_20 BLT_21 BLT_22 BLT_23 BLT_24 BLT_25 BLT_26 BLT_27
+  BLT_28 BLT_29 BLT_30 BLT_31 BLT_32 BLT_33 BLT_34 BLT_35 BLT_36 BLT_37
+  BLT_38 BLT_39 BLT_40 BLT_41 BLT_42 BLT_43 BLT_44 BLT_45 BLT_46 BLT_47
+  BLT_48 BLT_49 BLT_50 BLT_51 BLT_52 BLT_53 BLT_54 BLT_55 BLT_56 BLT_57
+  BLT_58 BLT_59 BLT_60 BLT_61 BLT_62 BLT_63 BLT_64 BLT_65 BLT_66 BLT_67
+  BLT_68 BLT_69 BLT_70 BLT_71 BLT_72 BLT_73 BLT_74 BLT_75 BLT_76 BLT_77
+  BLT_78 BLT_79 BLT_80 BLT_81 BLT_82 BLT_83 BLT_84 BLT_85 BLT_86 BLT_87
+  BLT_88 BLT_89 BLT_90 BLT_91 BLT_92 BLT_93 BLT_94 BLT_95 BLT_96 BLT_97
+  BLT_98 BLT_99 BLT_100 BLT_101 BLT_102 BLT_103 BLT_104 BLT_105 BLT_106
+  BLT_107 BLT_108 BLT_109 BLT_110 BLT_111 BLT_112 BLT_113 BLT_114 BLT_115
+  BLT_116 BLT_117 BLT_118 BLT_119 BLT_120 BLT_121 BLT_122 BLT_123 BLT_124
+  BLT_125 BLT_126 BLT_127 BLT__0 BLT__1 BLT__2 BLT__3 BLT__4 BLT__5 BLT__6
+  BLT__7 BLT__8 BLT__9 BLT__10 BLT__11 BLT__12 BLT__13 BLT__14 BLT__15
+  BLT__16 BLT__17 BLT__18 BLT__19 BLT__20 BLT__21 BLT__22 BLT__23 BLT__24
+  BLT__25 BLT__26 BLT__27 BLT__28 BLT__29 BLT__30 BLT__31 BLT__32 BLT__33
+  BLT__34 BLT__35 BLT__36 BLT__37 BLT__38 BLT__39 BLT__40 BLT__41 BLT__42
+  BLT__43 BLT__44 BLT__45 BLT__46 BLT__47 BLT__48 BLT__49 BLT__50 BLT__51
+  BLT__52 BLT__53 BLT__54 BLT__55 BLT__56 BLT__57 BLT__58 BLT__59 BLT__60
+  BLT__61 BLT__62 BLT__63 BLT__64 BLT__65 BLT__66 BLT__67 BLT__68 BLT__69
+  BLT__70 BLT__71 BLT__72 BLT__73 BLT__74 BLT__75 BLT__76 BLT__77 BLT__78
+  BLT__79 BLT__80 BLT__81 BLT__82 BLT__83 BLT__84 BLT__85 BLT__86 BLT__87
+  BLT__88 BLT__89 BLT__90 BLT__91 BLT__92 BLT__93 BLT__94 BLT__95 BLT__96
+  BLT__97 BLT__98 BLT__99 BLT__100 BLT__101 BLT__102 BLT__103 BLT__104
+  BLT__105 BLT__106 BLT__107 BLT__108 BLT__109 BLT__110 BLT__111 BLT__112
+  BLT__113 BLT__114 BLT__115 BLT__116 BLT__117 BLT__118 BLT__119 BLT__120
+  BLT__121 BLT__122 BLT__123 BLT__124 BLT__125 BLT__126 BLT__127 D_0 D_1 D_2
+  D_3 D_4 D_5 D_6 D_7 GTP_0 GTP_1 GTP_2 OE_ Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  STUBDR_0 STUBDR_1 STUBDR__0 STUBDR__1 STUBDW_0 STUBDW_1 STUBDW__0 STUBDW__1
+  WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72
+  WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84
+  WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96
+  WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107
+  WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117
+  WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127
+  WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137
+  WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147
+  WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157
+  WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167
+  WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177
+  WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187
+  WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197
+  WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207
+  WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217
+  WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227
+  WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237
+  WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247
+  WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMWING_8_RIGHT: 201736 flat devices **
XI0_0 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6 BLT_7 BLT_8 BLT_9
+  BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT__0 BLT__1 BLT__2 BLT__3
+  BLT__4 BLT__5 BLT__6 BLT__7 BLT__8 BLT__9 BLT__10 BLT__11 BLT__12 BLT__13
+  BLT__14 BLT__15 D_0 GTP_0 GTP_1 GTP_2 OE_ Q_0 STUBDR_0_10 STUBDR_1
+  STUBDR__0_8 STUBDR__1 STUBDW_0_12 STUBDW_1 STUBDW__0_14 STUBDW__1 WE WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66
+  WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78
+  WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90
+  WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102
+  WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112
+  WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122
+  WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132
+  WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142
+  WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152
+  WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162
+  WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172
+  WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182
+  WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192
+  WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202
+  WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212
+  WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222
+  WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232
+  WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242
+  WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252
+  WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS SIGN_MEMMCOL_EVEN_M16
XI10_0 A0 A0_ BLT_127 BLT_126 BLT_125 BLT_124 BLT_123 BLT_122 BLT_121 BLT_120
+  BLT_119 BLT_118 BLT_117 BLT_116 BLT_115 BLT_114 BLT_113 BLT_112 BLT__127
+  BLT__126 BLT__125 BLT__124 BLT__123 BLT__122 BLT__121 BLT__120 BLT__119
+  BLT__118 BLT__117 BLT__116 BLT__115 BLT__114 BLT__113 BLT__112 D_7 GTP_0
+  GTP_1 GTP_2 OE_ Q_7 STUBDR_0_2 STUBDR_0 STUBDR__0_0 STUBDR__0 STUBDW_0_4
+  STUBDW_0 STUBDW__0_6 STUBDW__0 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_R16
XI1_0 A0 A0_ BLT_31 BLT_30 BLT_29 BLT_28 BLT_27 BLT_26 BLT_25 BLT_24 BLT_23
+  BLT_22 BLT_21 BLT_20 BLT_19 BLT_18 BLT_17 BLT_16 BLT__31 BLT__30 BLT__29
+  BLT__28 BLT__27 BLT__26 BLT__25 BLT__24 BLT__23 BLT__22 BLT__21 BLT__20
+  BLT__19 BLT__18 BLT__17 BLT__16 D_1 GTP_0 GTP_1 GTP_2 OE_ Q_1 STUBDR_0_10
+  STUBDR_1_18 STUBDR__0_8 STUBDR__1_16 STUBDW_0_12 STUBDW_1_20 STUBDW__0_14
+  STUBDW__1_22 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_M16
XI2_0 A0 A0_ STUBDR_1_18 STUBDR__1_16 STUBDW_1_20 STUBDW__1_22 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI3_0 A0 A0_ BLT_32 BLT_33 BLT_34 BLT_35 BLT_36 BLT_37 BLT_38 BLT_39 BLT_40
+  BLT_41 BLT_42 BLT_43 BLT_44 BLT_45 BLT_46 BLT_47 BLT__32 BLT__33 BLT__34
+  BLT__35 BLT__36 BLT__37 BLT__38 BLT__39 BLT__40 BLT__41 BLT__42 BLT__43
+  BLT__44 BLT__45 BLT__46 BLT__47 D_2 GTP_0 GTP_1 GTP_2 OE_ Q_2 STUBDR_0_26
+  STUBDR_1_18 STUBDR__0_24 STUBDR__1_16 STUBDW_0_28 STUBDW_1_20 STUBDW__0_30
+  STUBDW__1_22 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_M16
XI4_0 A0 A0_ BLT_63 BLT_62 BLT_61 BLT_60 BLT_59 BLT_58 BLT_57 BLT_56 BLT_55
+  BLT_54 BLT_53 BLT_52 BLT_51 BLT_50 BLT_49 BLT_48 BLT__63 BLT__62 BLT__61
+  BLT__60 BLT__59 BLT__58 BLT__57 BLT__56 BLT__55 BLT__54 BLT__53 BLT__52
+  BLT__51 BLT__50 BLT__49 BLT__48 D_3 GTP_0 GTP_1 GTP_2 OE_ Q_3 STUBDR_0_26
+  STUBDR_1_34 STUBDR__0_24 STUBDR__1_32 STUBDW_0_28 STUBDW_1_36 STUBDW__0_30
+  STUBDW__1_38 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_M16
XI5_0 A0 A0_ STUBDR_1_34 STUBDR__1_32 STUBDW_1_36 STUBDW__1_38 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI6_0 A0 A0_ BLT_64 BLT_65 BLT_66 BLT_67 BLT_68 BLT_69 BLT_70 BLT_71 BLT_72
+  BLT_73 BLT_74 BLT_75 BLT_76 BLT_77 BLT_78 BLT_79 BLT__64 BLT__65 BLT__66
+  BLT__67 BLT__68 BLT__69 BLT__70 BLT__71 BLT__72 BLT__73 BLT__74 BLT__75
+  BLT__76 BLT__77 BLT__78 BLT__79 D_4 GTP_0 GTP_1 GTP_2 OE_ Q_4 STUBDR_0_42
+  STUBDR_1_34 STUBDR__0_40 STUBDR__1_32 STUBDW_0_44 STUBDW_1_36 STUBDW__0_46
+  STUBDW__1_38 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_EVEN_M16
XI7_0 A0 A0_ BLT_95 BLT_94 BLT_93 BLT_92 BLT_91 BLT_90 BLT_89 BLT_88 BLT_87
+  BLT_86 BLT_85 BLT_84 BLT_83 BLT_82 BLT_81 BLT_80 BLT__95 BLT__94 BLT__93
+  BLT__92 BLT__91 BLT__90 BLT__89 BLT__88 BLT__87 BLT__86 BLT__85 BLT__84
+  BLT__83 BLT__82 BLT__81 BLT__80 D_5 GTP_0 GTP_1 GTP_2 OE_ Q_5 STUBDR_0_42
+  STUBDR_1_50 STUBDR__0_40 STUBDR__1_48 STUBDW_0_44 STUBDW_1_52 STUBDW__0_46
+  STUBDW__1_54 WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70
+  WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82
+  WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94
+  WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105
+  WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115
+  WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125
+  WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135
+  WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145
+  WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155
+  WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165
+  WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175
+  WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185
+  WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195
+  WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205
+  WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215
+  WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225
+  WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235
+  WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245
+  WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74
+  WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86
+  WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98
+  WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109
+  WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119
+  WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129
+  WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139
+  WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149
+  WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159
+  WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169
+  WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179
+  WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189
+  WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199
+  WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209
+  WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219
+  WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229
+  WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239
+  WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249
+  WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMMCOL_ODD_M16
XI8_0 A0 A0_ STUBDR_1_50 STUBDR__1_48 STUBDW_1_52 STUBDW__1_54 GTP_0 GTP_1
+  GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCOL_STRAPX
XI9_0 A0 A0_ BLT_96 BLT_97 BLT_98 BLT_99 BLT_100 BLT_101 BLT_102 BLT_103
+  BLT_104 BLT_105 BLT_106 BLT_107 BLT_108 BLT_109 BLT_110 BLT_111 BLT__96
+  BLT__97 BLT__98 BLT__99 BLT__100 BLT__101 BLT__102 BLT__103 BLT__104
+  BLT__105 BLT__106 BLT__107 BLT__108 BLT__109 BLT__110 BLT__111 D_6 GTP_0
+  GTP_1 GTP_2 OE_ Q_6 STUBDR_0_2 STUBDR_1_50 STUBDR__0_0 STUBDR__1_48
+  STUBDW_0_4 STUBDW_1_52 STUBDW__0_6 STUBDW__1_54 WE WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
+  SIGN_MEMMCOL_EVEN_M16
.ENDS SIGN_MEMWING_8_RIGHT
****
.SUBCKT SIGN_MEMFLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMFLCIO: 11 flat devices **
d1 VSS A0_ tdndsx AREA=0.1024P PERIM=1.28U
d10 VSS YP1_0 tdndsx AREA=0.1024P PERIM=1.28U
d11 VSS GTP tdndsx AREA=0.1024P PERIM=1.28U
d2 VSS A0 tdndsx AREA=0.1024P PERIM=1.28U
d3 VSS YP0_0 tdndsx AREA=0.1024P PERIM=1.28U
d4 VSS YP0_1 tdndsx AREA=0.1024P PERIM=1.28U
d5 VSS YP0_2 tdndsx AREA=0.1024P PERIM=1.28U
d6 VSS YP0_3 tdndsx AREA=0.1024P PERIM=1.28U
d7 VSS YP1_3 tdndsx AREA=0.1024P PERIM=1.28U
d8 VSS YP1_2 tdndsx AREA=0.1024P PERIM=1.28U
d9 VSS YP1_1 tdndsx AREA=0.1024P PERIM=1.28U
.ENDS SIGN_MEMFLCIO
****
.SUBCKT SIGN_MEMFLCIOX A0 A0_ BL BL_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
** SIGN_MEMFLCIOX: 11 flat devices **
XI0_0 A0 A0_ CLK GSRCN GTP GTPN BL_ BL RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS SIGN_MEMFLCIO
.ENDS SIGN_MEMFLCIOX
****
.SUBCKT SIGN_MEMRIGHT_CAP A0 A0_ GTP_0 GTP_1 GTP_2 OE_ WE WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76
+  WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88
+  WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100
+  WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110
+  WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120
+  WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130
+  WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140
+  WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150
+  WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160
+  WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170
+  WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180
+  WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190
+  WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200
+  WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210
+  WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220
+  WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230
+  WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240
+  WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250
+  WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VDD VSS
** SIGN_MEMRIGHT_CAP: 262 flat devices **
XI0_0 GTP_0 OE_ WE VDD VSS SIGN_MEMFCIO8
XI0_1 GTP_1 VDD VSS SIGN_MEMFCSA8
XI0_10 NDL_183 WL_6 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_100 NDL_5 WL_96 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_101 NDL_5 WL_97 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_102 NDL_7 WL_98 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_103 NDL_7 WL_99 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_104 NDL_9 WL_100 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_105 NDL_9 WL_101 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_106 NDL_11 WL_102 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_107 NDL_11 WL_103 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_108 NDL_15 WL_104 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_109 NDL_15 WL_105 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_11 NDL_183 WL_7 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_110 NDL_37 WL_106 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_111 NDL_37 WL_107 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_112 NDL_39 WL_108 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_113 NDL_39 WL_109 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_114 NDL_41 WL_110 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_115 NDL_41 WL_111 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_116 NDL_43 WL_112 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_117 NDL_43 WL_113 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_118 NDL_45 WL_114 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_119 NDL_45 WL_115 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_12 NDL_185 WL_8 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_120 NDL_69 WL_116 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_121 NDL_69 WL_117 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_122 NDL_73 WL_118 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_123 NDL_73 WL_119 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_124 NDL_77 WL_120 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_125 NDL_77 WL_121 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_126 NDL_81 WL_122 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_127 NDL_81 WL_123 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_128 NDL_85 WL_124 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_129 NDL_85 WL_125 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_13 NDL_185 WL_9 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_130 NDL_101 WL_126 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_131 NDL_101 WL_127 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_132 NDL_107 WL_128 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_133 NDL_107 WL_129 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_134 NDL_113 WL_130 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_135 NDL_113 WL_131 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_136 NDL_117 WL_132 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_137 NDL_117 WL_133 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_138 NDL_121 WL_134 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_139 NDL_121 WL_135 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_14 NDL_187 WL_10 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_140 NDL_135 WL_136 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_141 NDL_135 WL_137 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_142 NDL_139 WL_138 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_143 NDL_139 WL_139 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_144 NDL_143 WL_140 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_145 NDL_143 WL_141 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_146 NDL_147 WL_142 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_147 NDL_147 WL_143 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_148 NDL_151 WL_144 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_149 NDL_151 WL_145 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_15 NDL_187 WL_11 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_150 NDL_165 WL_146 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_151 NDL_165 WL_147 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_152 NDL_169 WL_148 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_153 NDL_169 WL_149 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_154 NDL_173 WL_150 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_155 NDL_173 WL_151 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_156 NDL_177 WL_152 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_157 NDL_177 WL_153 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_158 NDL_181 WL_154 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_159 NDL_181 WL_155 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_16 NDL_189 WL_12 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_160 NDL_205 WL_156 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_161 NDL_205 WL_157 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_162 NDL_209 WL_158 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_163 NDL_209 WL_159 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_164 NDL_213 WL_160 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_165 NDL_213 WL_161 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_166 NDL_217 WL_162 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_167 NDL_217 WL_163 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_168 NDL_221 WL_164 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_169 NDL_221 WL_165 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_17 NDL_189 WL_13 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_170 NDL_235 WL_166 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_171 NDL_235 WL_167 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_172 NDL_239 WL_168 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_173 NDL_239 WL_169 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_174 NDL_243 WL_170 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_175 NDL_243 WL_171 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_176 NDL_247 WL_172 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_177 NDL_247 WL_173 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_178 NDL_251 WL_174 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_179 NDL_251 WL_175 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_18 NDL_191 WL_14 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_180 NDL_17 WL_176 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_181 NDL_17 WL_177 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_182 NDL_19 WL_178 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_183 NDL_19 WL_179 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_184 NDL_21 WL_180 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_185 NDL_21 WL_181 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_186 NDL_23 WL_182 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_187 NDL_23 WL_183 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_188 NDL_25 WL_184 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_189 NDL_25 WL_185 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_19 NDL_191 WL_15 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_190 NDL_47 WL_186 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_191 NDL_47 WL_187 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_192 NDL_49 WL_188 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_193 NDL_49 WL_189 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_194 NDL_51 WL_190 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_195 NDL_51 WL_191 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_196 NDL_53 WL_192 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_197 NDL_53 WL_193 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_198 NDL_55 WL_194 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_199 NDL_55 WL_195 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_20 NDL_223 WL_16 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_200 NDL_67 WL_196 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_201 NDL_67 WL_197 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_202 NDL_71 WL_198 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_203 NDL_71 WL_199 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_204 NDL_75 WL_200 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_205 NDL_75 WL_201 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_206 NDL_79 WL_202 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_207 NDL_79 WL_203 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_208 NDL_83 WL_204 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_209 NDL_83 WL_205 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_21 NDL_223 WL_17 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_210 NDL_97 WL_206 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_211 NDL_97 WL_207 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_212 NDL_103 WL_208 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_213 NDL_103 WL_209 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_214 NDL_109 WL_210 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_215 NDL_109 WL_211 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_216 NDL_115 WL_212 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_217 NDL_115 WL_213 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_218 NDL_119 WL_214 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_219 NDL_119 WL_215 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_22 NDL_225 WL_18 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_220 NDL_133 WL_216 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_221 NDL_133 WL_217 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_222 NDL_137 WL_218 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_223 NDL_137 WL_219 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_224 NDL_141 WL_220 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_225 NDL_141 WL_221 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_226 NDL_145 WL_222 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_227 NDL_145 WL_223 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_228 NDL_149 WL_224 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_229 NDL_149 WL_225 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_23 NDL_225 WL_19 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_230 NDL_163 WL_226 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_231 NDL_163 WL_227 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_232 NDL_167 WL_228 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_233 NDL_167 WL_229 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_234 NDL_171 WL_230 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_235 NDL_171 WL_231 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_236 NDL_175 WL_232 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_237 NDL_175 WL_233 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_238 NDL_179 WL_234 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_239 NDL_179 WL_235 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_24 NDL_227 WL_20 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_240 NDL_203 WL_236 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_241 NDL_203 WL_237 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_242 NDL_207 WL_238 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_243 NDL_207 WL_239 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_244 NDL_211 WL_240 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_245 NDL_211 WL_241 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_246 NDL_215 WL_242 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_247 NDL_215 WL_243 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_248 NDL_219 WL_244 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_249 NDL_219 WL_245 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_25 NDL_227 WL_21 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_250 NDL_233 WL_246 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_251 NDL_233 WL_247 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_252 NDL_237 WL_248 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_253 NDL_237 WL_249 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_254 NDL_241 WL_250 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_255 NDL_241 WL_251 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_256 NDL_245 WL_252 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_257 NDL_245 WL_253 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_258 NDL_249 WL_254 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_259 NDL_249 WL_255 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_26 NDL_229 WL_22 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_261 NDL_13 VSS VDD VSS SIGN_MEMFLCCSTRAPR
XI0_262 NDL_13 VSS VDD VSS SIGN_MEMFLCCSTRAPR
XI0_27 NDL_229 WL_23 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_28 NDL_231 WL_24 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_29 NDL_231 WL_25 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_30 NDL_253 WL_26 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_31 NDL_253 WL_27 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_32 NDL_255 WL_28 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_33 NDL_255 WL_29 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_34 NDL WL_30 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_35 NDL WL_31 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_36 NDL_1 WL_32 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_37 NDL_1 WL_33 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_38 NDL_3 WL_34 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_39 NDL_3 WL_35 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_4 NDL_99 WL_0 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_40 NDL_27 WL_36 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_41 NDL_27 WL_37 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_42 NDL_29 WL_38 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_43 NDL_29 WL_39 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_44 NDL_31 WL_40 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_45 NDL_31 WL_41 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_46 NDL_33 WL_42 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_47 NDL_33 WL_43 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_48 NDL_35 WL_44 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_49 NDL_35 WL_45 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_5 NDL_99 WL_1 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_50 NDL_57 WL_46 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_51 NDL_57 WL_47 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_52 NDL_59 WL_48 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_53 NDL_59 WL_49 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_54 NDL_61 WL_50 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_55 NDL_61 WL_51 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_56 NDL_63 WL_52 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_57 NDL_63 WL_53 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_58 NDL_65 WL_54 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_59 NDL_65 WL_55 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_6 NDL_105 WL_2 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_60 NDL_87 WL_56 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_61 NDL_87 WL_57 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_62 NDL_89 WL_58 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_63 NDL_89 WL_59 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_64 NDL_91 WL_60 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_65 NDL_91 WL_61 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_66 NDL_93 WL_62 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_67 NDL_93 WL_63 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_68 NDL_95 WL_64 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_69 NDL_95 WL_65 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_7 NDL_105 WL_3 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_70 NDL_123 WL_66 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_71 NDL_123 WL_67 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_72 NDL_125 WL_68 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_73 NDL_125 WL_69 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_74 NDL_127 WL_70 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_75 NDL_127 WL_71 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_76 NDL_129 WL_72 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_77 NDL_129 WL_73 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_78 NDL_131 WL_74 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_79 NDL_131 WL_75 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_8 NDL_111 WL_4 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_80 NDL_153 WL_76 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_81 NDL_153 WL_77 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_82 NDL_155 WL_78 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_83 NDL_155 WL_79 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_84 NDL_157 WL_80 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_85 NDL_157 WL_81 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_86 NDL_159 WL_82 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_87 NDL_159 WL_83 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_88 NDL_161 WL_84 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_89 NDL_161 WL_85 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_9 NDL_111 WL_5 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_90 NDL_193 WL_86 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_91 NDL_193 WL_87 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_92 NDL_195 WL_88 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_93 NDL_195 WL_89 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_94 NDL_197 WL_90 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_95 NDL_197 WL_91 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_96 NDL_199 WL_92 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_97 NDL_199 WL_93 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_98 NDL_201 WL_94 VDD VSS SIGN_MEMFLCCSTRAPR
XI0_99 NDL_201 WL_95 VDD VSS SIGN_MEMFLCCSTRAPR
.ENDS SIGN_MEMRIGHT_CAP
****
.SUBCKT SIGN_MEMFLCCMBLST2 NDR WL VDD VSS
** SIGN_MEMFLCCMBLST2: 1 flat devices **
m1 VSS VSS NDR VSS LPNFET L=0.13U W=0.16U
.ENDS SIGN_MEMFLCCMBLST2
****
.SUBCKT SIGN_MEMFLCCMBLST NDL NDR WL WP VDD VSS
** SIGN_MEMFLCCMBLST: 2 flat devices **
m1 VSS WL NDR VSS LPNFET L=0.13U W=0.16U
m2 VSS WP NDL VSS LPNFET L=0.13U W=0.16U
.ENDS SIGN_MEMFLCCMBLST
****
.SUBCKT SIGN_MEMFLCCMBLSTU NDR WL VDD VSS
** SIGN_MEMFLCCMBLSTU: 1 flat devices **
m1 VSS WL NDR VSS LPNFET L=0.13U W=0.16U
.ENDS SIGN_MEMFLCCMBLSTU
****
.SUBCKT SIGN_MEMMODEL_COL BL BL_ WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 WL_256 WL_257 VDD VSS
** SIGN_MEMMODEL_COL: 2306 flat devices **
XI0_0 NDR WL_0 VDD VSS SIGN_MEMFLCCMBLST2
XI0_1 NDR WL_1 VDD VSS SIGN_MEMFLCCMBLST2
XI0_10 NDR_128 WL_10 VDD VSS SIGN_MEMFLCCMBLST2
XI0_100 NDR_28 WL_100 VDD VSS SIGN_MEMFLCCMBLST2
XI0_101 NDR_28 WL_101 VDD VSS SIGN_MEMFLCCMBLST2
XI0_102 NDR_30 WL_102 VDD VSS SIGN_MEMFLCCMBLST2
XI0_103 NDR_30 WL_103 VDD VSS SIGN_MEMFLCCMBLST2
XI0_104 NDR_32 WL_104 VDD VSS SIGN_MEMFLCCMBLST2
XI0_105 NDR_32 WL_105 VDD VSS SIGN_MEMFLCCMBLST2
XI0_106 NDR_34 WL_106 VDD VSS SIGN_MEMFLCCMBLST2
XI0_107 NDR_34 WL_107 VDD VSS SIGN_MEMFLCCMBLST2
XI0_108 NDR_36 WL_108 VDD VSS SIGN_MEMFLCCMBLST2
XI0_109 NDR_36 WL_109 VDD VSS SIGN_MEMFLCCMBLST2
XI0_11 NDR_128 WL_11 VDD VSS SIGN_MEMFLCCMBLST2
XI0_110 NDR_38 WL_110 VDD VSS SIGN_MEMFLCCMBLST2
XI0_111 NDR_38 WL_111 VDD VSS SIGN_MEMFLCCMBLST2
XI0_112 NDR_40 WL_112 VDD VSS SIGN_MEMFLCCMBLST2
XI0_113 NDR_40 WL_113 VDD VSS SIGN_MEMFLCCMBLST2
XI0_114 NDR_42 WL_114 VDD VSS SIGN_MEMFLCCMBLST2
XI0_115 NDR_42 WL_115 VDD VSS SIGN_MEMFLCCMBLST2
XI0_116 NDR_44 WL_116 VDD VSS SIGN_MEMFLCCMBLST2
XI0_117 NDR_44 WL_117 VDD VSS SIGN_MEMFLCCMBLST2
XI0_118 NDR_46 WL_118 VDD VSS SIGN_MEMFLCCMBLST2
XI0_119 NDR_46 WL_119 VDD VSS SIGN_MEMFLCCMBLST2
XI0_12 NDR_130 WL_12 VDD VSS SIGN_MEMFLCCMBLST2
XI0_120 NDR_50 WL_120 VDD VSS SIGN_MEMFLCCMBLST2
XI0_121 NDR_50 WL_121 VDD VSS SIGN_MEMFLCCMBLST2
XI0_122 NDR_54 WL_122 VDD VSS SIGN_MEMFLCCMBLST2
XI0_123 NDR_54 WL_123 VDD VSS SIGN_MEMFLCCMBLST2
XI0_124 NDR_58 WL_124 VDD VSS SIGN_MEMFLCCMBLST2
XI0_125 NDR_58 WL_125 VDD VSS SIGN_MEMFLCCMBLST2
XI0_126 NDR_62 WL_126 VDD VSS SIGN_MEMFLCCMBLST2
XI0_127 NDR_62 WL_127 VDD VSS SIGN_MEMFLCCMBLST2
XI0_128 NDR_66 WL_128 VDD VSS SIGN_MEMFLCCMBLST2
XI0_129 NDR_66 WL_129 VDD VSS SIGN_MEMFLCCMBLST2
XI0_13 NDR_130 WL_13 VDD VSS SIGN_MEMFLCCMBLST2
XI0_130 NDR_70 WL_130 VDD VSS SIGN_MEMFLCCMBLST2
XI0_131 NDR_70 WL_131 VDD VSS SIGN_MEMFLCCMBLST2
XI0_132 NDR_74 WL_132 VDD VSS SIGN_MEMFLCCMBLST2
XI0_133 NDR_74 WL_133 VDD VSS SIGN_MEMFLCCMBLST2
XI0_134 NDR_78 WL_134 VDD VSS SIGN_MEMFLCCMBLST2
XI0_135 NDR_78 WL_135 VDD VSS SIGN_MEMFLCCMBLST2
XI0_136 NDR_82 WL_136 VDD VSS SIGN_MEMFLCCMBLST2
XI0_137 NDR_82 WL_137 VDD VSS SIGN_MEMFLCCMBLST2
XI0_138 NDR_86 WL_138 VDD VSS SIGN_MEMFLCCMBLST2
XI0_139 NDR_86 WL_139 VDD VSS SIGN_MEMFLCCMBLST2
XI0_14 NDR_132 WL_14 VDD VSS SIGN_MEMFLCCMBLST2
XI0_140 NDR_90 WL_140 VDD VSS SIGN_MEMFLCCMBLST2
XI0_141 NDR_90 WL_141 VDD VSS SIGN_MEMFLCCMBLST2
XI0_142 NDR_94 WL_142 VDD VSS SIGN_MEMFLCCMBLST2
XI0_143 NDR_94 WL_143 VDD VSS SIGN_MEMFLCCMBLST2
XI0_144 NDR_98 WL_144 VDD VSS SIGN_MEMFLCCMBLST2
XI0_145 NDR_98 WL_145 VDD VSS SIGN_MEMFLCCMBLST2
XI0_146 NDR_102 WL_146 VDD VSS SIGN_MEMFLCCMBLST2
XI0_147 NDR_102 WL_147 VDD VSS SIGN_MEMFLCCMBLST2
XI0_148 NDR_106 WL_148 VDD VSS SIGN_MEMFLCCMBLST2
XI0_149 NDR_106 WL_149 VDD VSS SIGN_MEMFLCCMBLST2
XI0_15 NDR_132 WL_15 VDD VSS SIGN_MEMFLCCMBLST2
XI0_150 NDR_110 WL_150 VDD VSS SIGN_MEMFLCCMBLST2
XI0_151 NDR_110 WL_151 VDD VSS SIGN_MEMFLCCMBLST2
XI0_152 NDR_114 WL_152 VDD VSS SIGN_MEMFLCCMBLST2
XI0_153 NDR_114 WL_153 VDD VSS SIGN_MEMFLCCMBLST2
XI0_154 NDR_118 WL_154 VDD VSS SIGN_MEMFLCCMBLST2
XI0_155 NDR_118 WL_155 VDD VSS SIGN_MEMFLCCMBLST2
XI0_156 NDR_122 WL_156 VDD VSS SIGN_MEMFLCCMBLST2
XI0_157 NDR_122 WL_157 VDD VSS SIGN_MEMFLCCMBLST2
XI0_158 NDR_126 WL_158 VDD VSS SIGN_MEMFLCCMBLST2
XI0_159 NDR_126 WL_159 VDD VSS SIGN_MEMFLCCMBLST2
XI0_16 NDR_134 WL_16 VDD VSS SIGN_MEMFLCCMBLST2
XI0_160 NDR_140 WL_160 VDD VSS SIGN_MEMFLCCMBLST2
XI0_161 NDR_140 WL_161 VDD VSS SIGN_MEMFLCCMBLST2
XI0_162 NDR_144 WL_162 VDD VSS SIGN_MEMFLCCMBLST2
XI0_163 NDR_144 WL_163 VDD VSS SIGN_MEMFLCCMBLST2
XI0_164 NDR_148 WL_164 VDD VSS SIGN_MEMFLCCMBLST2
XI0_165 NDR_148 WL_165 VDD VSS SIGN_MEMFLCCMBLST2
XI0_166 NDR_152 WL_166 VDD VSS SIGN_MEMFLCCMBLST2
XI0_167 NDR_152 WL_167 VDD VSS SIGN_MEMFLCCMBLST2
XI0_168 NDR_156 WL_168 VDD VSS SIGN_MEMFLCCMBLST2
XI0_169 NDR_156 WL_169 VDD VSS SIGN_MEMFLCCMBLST2
XI0_17 NDR_134 WL_17 VDD VSS SIGN_MEMFLCCMBLST2
XI0_170 NDR_170 WL_170 VDD VSS SIGN_MEMFLCCMBLST2
XI0_171 NDR_170 WL_171 VDD VSS SIGN_MEMFLCCMBLST2
XI0_172 NDR_174 WL_172 VDD VSS SIGN_MEMFLCCMBLST2
XI0_173 NDR_174 WL_173 VDD VSS SIGN_MEMFLCCMBLST2
XI0_174 NDR_178 WL_174 VDD VSS SIGN_MEMFLCCMBLST2
XI0_175 NDR_178 WL_175 VDD VSS SIGN_MEMFLCCMBLST2
XI0_176 NDR_180 WL_176 VDD VSS SIGN_MEMFLCCMBLST2
XI0_177 NDR_180 WL_177 VDD VSS SIGN_MEMFLCCMBLST2
XI0_178 NDR_182 WL_178 VDD VSS SIGN_MEMFLCCMBLST2
XI0_179 NDR_182 WL_179 VDD VSS SIGN_MEMFLCCMBLST2
XI0_18 NDR_136 WL_18 VDD VSS SIGN_MEMFLCCMBLST2
XI0_180 NDR_206 WL_180 VDD VSS SIGN_MEMFLCCMBLST2
XI0_181 NDR_206 WL_181 VDD VSS SIGN_MEMFLCCMBLST2
XI0_182 NDR_212 WL_182 VDD VSS SIGN_MEMFLCCMBLST2
XI0_183 NDR_212 WL_183 VDD VSS SIGN_MEMFLCCMBLST2
XI0_184 NDR_218 WL_184 VDD VSS SIGN_MEMFLCCMBLST2
XI0_185 NDR_218 WL_185 VDD VSS SIGN_MEMFLCCMBLST2
XI0_186 NDR_220 WL_186 VDD VSS SIGN_MEMFLCCMBLST2
XI0_187 NDR_220 WL_187 VDD VSS SIGN_MEMFLCCMBLST2
XI0_188 NDR_222 WL_188 VDD VSS SIGN_MEMFLCCMBLST2
XI0_189 NDR_222 WL_189 VDD VSS SIGN_MEMFLCCMBLST2
XI0_19 NDR_136 WL_19 VDD VSS SIGN_MEMFLCCMBLST2
XI0_190 NDR_250 WL_190 VDD VSS SIGN_MEMFLCCMBLST2
XI0_191 NDR_250 WL_191 VDD VSS SIGN_MEMFLCCMBLST2
XI0_192 NDR_256 WL_192 VDD VSS SIGN_MEMFLCCMBLST2
XI0_193 NDR_256 WL_193 VDD VSS SIGN_MEMFLCCMBLST2
XI0_194 NDR_258 WL_194 VDD VSS SIGN_MEMFLCCMBLST2
XI0_195 NDR_258 WL_195 VDD VSS SIGN_MEMFLCCMBLST2
XI0_196 NDR_260 WL_196 VDD VSS SIGN_MEMFLCCMBLST2
XI0_197 NDR_260 WL_197 VDD VSS SIGN_MEMFLCCMBLST2
XI0_198 NDR_262 WL_198 VDD VSS SIGN_MEMFLCCMBLST2
XI0_199 NDR_262 WL_199 VDD VSS SIGN_MEMFLCCMBLST2
XI0_2 NDR_1 WL_2 VDD VSS SIGN_MEMFLCCMBLST2
XI0_20 NDR_158 WL_20 VDD VSS SIGN_MEMFLCCMBLST2
XI0_200 NDR_48 WL_200 VDD VSS SIGN_MEMFLCCMBLST2
XI0_201 NDR_48 WL_201 VDD VSS SIGN_MEMFLCCMBLST2
XI0_202 NDR_52 WL_202 VDD VSS SIGN_MEMFLCCMBLST2
XI0_203 NDR_52 WL_203 VDD VSS SIGN_MEMFLCCMBLST2
XI0_204 NDR_56 WL_204 VDD VSS SIGN_MEMFLCCMBLST2
XI0_205 NDR_56 WL_205 VDD VSS SIGN_MEMFLCCMBLST2
XI0_206 NDR_60 WL_206 VDD VSS SIGN_MEMFLCCMBLST2
XI0_207 NDR_60 WL_207 VDD VSS SIGN_MEMFLCCMBLST2
XI0_208 NDR_64 WL_208 VDD VSS SIGN_MEMFLCCMBLST2
XI0_209 NDR_64 WL_209 VDD VSS SIGN_MEMFLCCMBLST2
XI0_21 NDR_158 WL_21 VDD VSS SIGN_MEMFLCCMBLST2
XI0_210 NDR_68 WL_210 VDD VSS SIGN_MEMFLCCMBLST2
XI0_211 NDR_68 WL_211 VDD VSS SIGN_MEMFLCCMBLST2
XI0_212 NDR_72 WL_212 VDD VSS SIGN_MEMFLCCMBLST2
XI0_213 NDR_72 WL_213 VDD VSS SIGN_MEMFLCCMBLST2
XI0_214 NDR_76 WL_214 VDD VSS SIGN_MEMFLCCMBLST2
XI0_215 NDR_76 WL_215 VDD VSS SIGN_MEMFLCCMBLST2
XI0_216 NDR_80 WL_216 VDD VSS SIGN_MEMFLCCMBLST2
XI0_217 NDR_80 WL_217 VDD VSS SIGN_MEMFLCCMBLST2
XI0_218 NDR_84 WL_218 VDD VSS SIGN_MEMFLCCMBLST2
XI0_219 NDR_84 WL_219 VDD VSS SIGN_MEMFLCCMBLST2
XI0_22 NDR_160 WL_22 VDD VSS SIGN_MEMFLCCMBLST2
XI0_220 NDR_88 WL_220 VDD VSS SIGN_MEMFLCCMBLST2
XI0_221 NDR_88 WL_221 VDD VSS SIGN_MEMFLCCMBLST2
XI0_222 NDR_92 WL_222 VDD VSS SIGN_MEMFLCCMBLST2
XI0_223 NDR_92 WL_223 VDD VSS SIGN_MEMFLCCMBLST2
XI0_224 NDR_96 WL_224 VDD VSS SIGN_MEMFLCCMBLST2
XI0_225 NDR_96 WL_225 VDD VSS SIGN_MEMFLCCMBLST2
XI0_226 NDR_100 WL_226 VDD VSS SIGN_MEMFLCCMBLST2
XI0_227 NDR_100 WL_227 VDD VSS SIGN_MEMFLCCMBLST2
XI0_228 NDR_104 WL_228 VDD VSS SIGN_MEMFLCCMBLST2
XI0_229 NDR_104 WL_229 VDD VSS SIGN_MEMFLCCMBLST2
XI0_23 NDR_160 WL_23 VDD VSS SIGN_MEMFLCCMBLST2
XI0_230 NDR_108 WL_230 VDD VSS SIGN_MEMFLCCMBLST2
XI0_231 NDR_108 WL_231 VDD VSS SIGN_MEMFLCCMBLST2
XI0_232 NDR_112 WL_232 VDD VSS SIGN_MEMFLCCMBLST2
XI0_233 NDR_112 WL_233 VDD VSS SIGN_MEMFLCCMBLST2
XI0_234 NDR_116 WL_234 VDD VSS SIGN_MEMFLCCMBLST2
XI0_235 NDR_116 WL_235 VDD VSS SIGN_MEMFLCCMBLST2
XI0_236 NDR_120 WL_236 VDD VSS SIGN_MEMFLCCMBLST2
XI0_237 NDR_120 WL_237 VDD VSS SIGN_MEMFLCCMBLST2
XI0_238 NDR_124 WL_238 VDD VSS SIGN_MEMFLCCMBLST2
XI0_239 NDR_124 WL_239 VDD VSS SIGN_MEMFLCCMBLST2
XI0_24 NDR_162 WL_24 VDD VSS SIGN_MEMFLCCMBLST2
XI0_240 NDR_138 WL_240 VDD VSS SIGN_MEMFLCCMBLST2
XI0_241 NDR_138 WL_241 VDD VSS SIGN_MEMFLCCMBLST2
XI0_242 NDR_142 WL_242 VDD VSS SIGN_MEMFLCCMBLST2
XI0_243 NDR_142 WL_243 VDD VSS SIGN_MEMFLCCMBLST2
XI0_244 NDR_146 WL_244 VDD VSS SIGN_MEMFLCCMBLST2
XI0_245 NDR_146 WL_245 VDD VSS SIGN_MEMFLCCMBLST2
XI0_246 NDR_150 WL_246 VDD VSS SIGN_MEMFLCCMBLST2
XI0_247 NDR_150 WL_247 VDD VSS SIGN_MEMFLCCMBLST2
XI0_248 NDR_154 WL_248 VDD VSS SIGN_MEMFLCCMBLST2
XI0_249 NDR_154 WL_249 VDD VSS SIGN_MEMFLCCMBLST2
XI0_25 NDR_162 WL_25 VDD VSS SIGN_MEMFLCCMBLST2
XI0_250 NDR_168 WL_250 VDD VSS SIGN_MEMFLCCMBLST2
XI0_251 NDR_168 WL_251 VDD VSS SIGN_MEMFLCCMBLST2
XI0_252 NDR_172 WL_252 VDD VSS SIGN_MEMFLCCMBLST2
XI0_253 NDR_172 WL_253 VDD VSS SIGN_MEMFLCCMBLST2
XI0_254 NDR_176 WL_254 VDD VSS SIGN_MEMFLCCMBLST2
XI0_255 NDR_176 WL_255 VDD VSS SIGN_MEMFLCCMBLST2
XI0_26 NDR_164 WL_26 VDD VSS SIGN_MEMFLCCMBLST2
XI0_27 NDR_164 WL_27 VDD VSS SIGN_MEMFLCCMBLST2
XI0_28 NDR_166 WL_28 VDD VSS SIGN_MEMFLCCMBLST2
XI0_29 NDR_166 WL_29 VDD VSS SIGN_MEMFLCCMBLST2
XI0_3 NDR_1 WL_3 VDD VSS SIGN_MEMFLCCMBLST2
XI0_30 NDR_184 WL_30 VDD VSS SIGN_MEMFLCCMBLST2
XI0_31 NDR_184 WL_31 VDD VSS SIGN_MEMFLCCMBLST2
XI0_32 NDR_186 WL_32 VDD VSS SIGN_MEMFLCCMBLST2
XI0_33 NDR_186 WL_33 VDD VSS SIGN_MEMFLCCMBLST2
XI0_34 NDR_188 WL_34 VDD VSS SIGN_MEMFLCCMBLST2
XI0_35 NDR_188 WL_35 VDD VSS SIGN_MEMFLCCMBLST2
XI0_36 NDR_190 WL_36 VDD VSS SIGN_MEMFLCCMBLST2
XI0_37 NDR_190 WL_37 VDD VSS SIGN_MEMFLCCMBLST2
XI0_38 NDR_192 WL_38 VDD VSS SIGN_MEMFLCCMBLST2
XI0_39 NDR_192 WL_39 VDD VSS SIGN_MEMFLCCMBLST2
XI0_4 NDR_3 WL_4 VDD VSS SIGN_MEMFLCCMBLST2
XI0_40 NDR_224 WL_40 VDD VSS SIGN_MEMFLCCMBLST2
XI0_41 NDR_224 WL_41 VDD VSS SIGN_MEMFLCCMBLST2
XI0_42 NDR_226 WL_42 VDD VSS SIGN_MEMFLCCMBLST2
XI0_43 NDR_226 WL_43 VDD VSS SIGN_MEMFLCCMBLST2
XI0_44 NDR_228 WL_44 VDD VSS SIGN_MEMFLCCMBLST2
XI0_45 NDR_228 WL_45 VDD VSS SIGN_MEMFLCCMBLST2
XI0_46 NDR_230 WL_46 VDD VSS SIGN_MEMFLCCMBLST2
XI0_47 NDR_230 WL_47 VDD VSS SIGN_MEMFLCCMBLST2
XI0_48 NDR_232 WL_48 VDD VSS SIGN_MEMFLCCMBLST2
XI0_49 NDR_232 WL_49 VDD VSS SIGN_MEMFLCCMBLST2
XI0_5 NDR_3 WL_5 VDD VSS SIGN_MEMFLCCMBLST2
XI0_50 NDR_264 WL_50 VDD VSS SIGN_MEMFLCCMBLST2
XI0_51 NDR_264 WL_51 VDD VSS SIGN_MEMFLCCMBLST2
XI0_52 NDR_266 WL_52 VDD VSS SIGN_MEMFLCCMBLST2
XI0_53 NDR_266 WL_53 VDD VSS SIGN_MEMFLCCMBLST2
XI0_54 NDR_268 WL_54 VDD VSS SIGN_MEMFLCCMBLST2
XI0_55 NDR_268 WL_55 VDD VSS SIGN_MEMFLCCMBLST2
XI0_56 NDR_270 WL_56 VDD VSS SIGN_MEMFLCCMBLST2
XI0_57 NDR_270 WL_57 VDD VSS SIGN_MEMFLCCMBLST2
XI0_58 NDR_272 WL_58 VDD VSS SIGN_MEMFLCCMBLST2
XI0_59 NDR_272 WL_59 VDD VSS SIGN_MEMFLCCMBLST2
XI0_6 NDR_5 WL_6 VDD VSS SIGN_MEMFLCCMBLST2
XI0_60 NDR_314 WL_60 VDD VSS SIGN_MEMFLCCMBLST2
XI0_61 NDR_314 WL_61 VDD VSS SIGN_MEMFLCCMBLST2
XI0_62 NDR_316 WL_62 VDD VSS SIGN_MEMFLCCMBLST2
XI0_63 NDR_316 WL_63 VDD VSS SIGN_MEMFLCCMBLST2
XI0_64 NDR_318 WL_64 VDD VSS SIGN_MEMFLCCMBLST2
XI0_65 NDR_318 WL_65 VDD VSS SIGN_MEMFLCCMBLST2
XI0_66 NDR_320 WL_66 VDD VSS SIGN_MEMFLCCMBLST2
XI0_67 NDR_320 WL_67 VDD VSS SIGN_MEMFLCCMBLST2
XI0_68 NDR_322 WL_68 VDD VSS SIGN_MEMFLCCMBLST2
XI0_69 NDR_322 WL_69 VDD VSS SIGN_MEMFLCCMBLST2
XI0_7 NDR_5 WL_7 VDD VSS SIGN_MEMFLCCMBLST2
XI0_70 NDR_372 WL_70 VDD VSS SIGN_MEMFLCCMBLST2
XI0_71 NDR_372 WL_71 VDD VSS SIGN_MEMFLCCMBLST2
XI0_72 NDR_378 WL_72 VDD VSS SIGN_MEMFLCCMBLST2
XI0_73 NDR_378 WL_73 VDD VSS SIGN_MEMFLCCMBLST2
XI0_74 NDR_384 WL_74 VDD VSS SIGN_MEMFLCCMBLST2
XI0_75 NDR_384 WL_75 VDD VSS SIGN_MEMFLCCMBLST2
XI0_76 NDR_390 WL_76 VDD VSS SIGN_MEMFLCCMBLST2
XI0_77 NDR_390 WL_77 VDD VSS SIGN_MEMFLCCMBLST2
XI0_78 NDR_392 WL_78 VDD VSS SIGN_MEMFLCCMBLST2
XI0_79 NDR_392 WL_79 VDD VSS SIGN_MEMFLCCMBLST2
XI0_8 NDR_7 WL_8 VDD VSS SIGN_MEMFLCCMBLST2
XI0_80 NDR_442 WL_80 VDD VSS SIGN_MEMFLCCMBLST2
XI0_81 NDR_442 WL_81 VDD VSS SIGN_MEMFLCCMBLST2
XI0_82 NDR_452 WL_82 VDD VSS SIGN_MEMFLCCMBLST2
XI0_83 NDR_452 WL_83 VDD VSS SIGN_MEMFLCCMBLST2
XI0_84 NDR_458 WL_84 VDD VSS SIGN_MEMFLCCMBLST2
XI0_85 NDR_458 WL_85 VDD VSS SIGN_MEMFLCCMBLST2
XI0_86 NDR_460 WL_86 VDD VSS SIGN_MEMFLCCMBLST2
XI0_87 NDR_460 WL_87 VDD VSS SIGN_MEMFLCCMBLST2
XI0_88 NDR_462 WL_88 VDD VSS SIGN_MEMFLCCMBLST2
XI0_89 NDR_462 WL_89 VDD VSS SIGN_MEMFLCCMBLST2
XI0_9 NDR_7 WL_9 VDD VSS SIGN_MEMFLCCMBLST2
XI0_90 NDR_516 WL_90 VDD VSS SIGN_MEMFLCCMBLST2
XI0_91 NDR_516 WL_91 VDD VSS SIGN_MEMFLCCMBLST2
XI0_92 NDR_522 WL_92 VDD VSS SIGN_MEMFLCCMBLST2
XI0_93 NDR_522 WL_93 VDD VSS SIGN_MEMFLCCMBLST2
XI0_94 NDR_528 WL_94 VDD VSS SIGN_MEMFLCCMBLST2
XI0_95 NDR_528 WL_95 VDD VSS SIGN_MEMFLCCMBLST2
XI0_96 NDR_530 WL_96 VDD VSS SIGN_MEMFLCCMBLST2
XI0_97 NDR_530 WL_97 VDD VSS SIGN_MEMFLCCMBLST2
XI0_98 NDR_532 WL_98 VDD VSS SIGN_MEMFLCCMBLST2
XI0_99 NDR_532 WL_99 VDD VSS SIGN_MEMFLCCMBLST2
XI1_0 BL BL_ WL_0 VSS VDD VSS SIGN_MEMCCOP
XI1_1 BL_ BL WL_1 VSS VDD VSS SIGN_MEMCCOP
XI1_10 BL_ BL WL_10 VSS VDD VSS SIGN_MEMCCOP
XI1_100 BL BL_ WL_100 VSS VDD VSS SIGN_MEMCCOP
XI1_101 BL_ BL WL_101 VSS VDD VSS SIGN_MEMCCOP
XI1_102 BL_ BL WL_102 VSS VDD VSS SIGN_MEMCCOP
XI1_103 BL BL_ WL_103 VSS VDD VSS SIGN_MEMCCOP
XI1_104 BL BL_ WL_104 VSS VDD VSS SIGN_MEMCCOP
XI1_105 BL_ BL WL_105 VSS VDD VSS SIGN_MEMCCOP
XI1_106 BL_ BL WL_106 VSS VDD VSS SIGN_MEMCCOP
XI1_107 BL BL_ WL_107 VSS VDD VSS SIGN_MEMCCOP
XI1_108 BL BL_ WL_108 VSS VDD VSS SIGN_MEMCCOP
XI1_109 BL_ BL WL_109 VSS VDD VSS SIGN_MEMCCOP
XI1_11 BL BL_ WL_11 VSS VDD VSS SIGN_MEMCCOP
XI1_110 BL_ BL WL_110 VSS VDD VSS SIGN_MEMCCOP
XI1_111 BL BL_ WL_111 VSS VDD VSS SIGN_MEMCCOP
XI1_112 BL BL_ WL_112 VSS VDD VSS SIGN_MEMCCOP
XI1_113 BL_ BL WL_113 VSS VDD VSS SIGN_MEMCCOP
XI1_114 BL_ BL WL_114 VSS VDD VSS SIGN_MEMCCOP
XI1_115 BL BL_ WL_115 VSS VDD VSS SIGN_MEMCCOP
XI1_116 BL BL_ WL_116 VSS VDD VSS SIGN_MEMCCOP
XI1_117 BL_ BL WL_117 VSS VDD VSS SIGN_MEMCCOP
XI1_118 BL_ BL WL_118 VSS VDD VSS SIGN_MEMCCOP
XI1_119 BL BL_ WL_119 VSS VDD VSS SIGN_MEMCCOP
XI1_12 BL BL_ WL_12 VSS VDD VSS SIGN_MEMCCOP
XI1_120 BL BL_ WL_120 VSS VDD VSS SIGN_MEMCCOP
XI1_121 BL_ BL WL_121 VSS VDD VSS SIGN_MEMCCOP
XI1_122 BL_ BL WL_122 VSS VDD VSS SIGN_MEMCCOP
XI1_123 BL BL_ WL_123 VSS VDD VSS SIGN_MEMCCOP
XI1_124 BL BL_ WL_124 VSS VDD VSS SIGN_MEMCCOP
XI1_125 BL_ BL WL_125 VSS VDD VSS SIGN_MEMCCOP
XI1_126 BL_ BL WL_126 VSS VDD VSS SIGN_MEMCCOP
XI1_127 BL BL_ WL_127 VSS VDD VSS SIGN_MEMCCOP
XI1_128 BL BL_ WL_128 VSS VDD VSS SIGN_MEMCCOP
XI1_129 BL_ BL WL_129 VSS VDD VSS SIGN_MEMCCOP
XI1_13 BL_ BL WL_13 VSS VDD VSS SIGN_MEMCCOP
XI1_130 BL_ BL WL_130 VSS VDD VSS SIGN_MEMCCOP
XI1_131 BL BL_ WL_131 VSS VDD VSS SIGN_MEMCCOP
XI1_132 BL BL_ WL_132 VSS VDD VSS SIGN_MEMCCOP
XI1_133 BL_ BL WL_133 VSS VDD VSS SIGN_MEMCCOP
XI1_134 BL_ BL WL_134 VSS VDD VSS SIGN_MEMCCOP
XI1_135 BL BL_ WL_135 VSS VDD VSS SIGN_MEMCCOP
XI1_136 BL BL_ WL_136 VSS VDD VSS SIGN_MEMCCOP
XI1_137 BL_ BL WL_137 VSS VDD VSS SIGN_MEMCCOP
XI1_138 BL_ BL WL_138 VSS VDD VSS SIGN_MEMCCOP
XI1_139 BL BL_ WL_139 VSS VDD VSS SIGN_MEMCCOP
XI1_14 BL_ BL WL_14 VSS VDD VSS SIGN_MEMCCOP
XI1_140 BL BL_ WL_140 VSS VDD VSS SIGN_MEMCCOP
XI1_141 BL_ BL WL_141 VSS VDD VSS SIGN_MEMCCOP
XI1_142 BL_ BL WL_142 VSS VDD VSS SIGN_MEMCCOP
XI1_143 BL BL_ WL_143 VSS VDD VSS SIGN_MEMCCOP
XI1_144 BL BL_ WL_144 VSS VDD VSS SIGN_MEMCCOP
XI1_145 BL_ BL WL_145 VSS VDD VSS SIGN_MEMCCOP
XI1_146 BL_ BL WL_146 VSS VDD VSS SIGN_MEMCCOP
XI1_147 BL BL_ WL_147 VSS VDD VSS SIGN_MEMCCOP
XI1_148 BL BL_ WL_148 VSS VDD VSS SIGN_MEMCCOP
XI1_149 BL_ BL WL_149 VSS VDD VSS SIGN_MEMCCOP
XI1_15 BL BL_ WL_15 VSS VDD VSS SIGN_MEMCCOP
XI1_150 BL_ BL WL_150 VSS VDD VSS SIGN_MEMCCOP
XI1_151 BL BL_ WL_151 VSS VDD VSS SIGN_MEMCCOP
XI1_152 BL BL_ WL_152 VSS VDD VSS SIGN_MEMCCOP
XI1_153 BL_ BL WL_153 VSS VDD VSS SIGN_MEMCCOP
XI1_154 BL_ BL WL_154 VSS VDD VSS SIGN_MEMCCOP
XI1_155 BL BL_ WL_155 VSS VDD VSS SIGN_MEMCCOP
XI1_156 BL BL_ WL_156 VSS VDD VSS SIGN_MEMCCOP
XI1_157 BL_ BL WL_157 VSS VDD VSS SIGN_MEMCCOP
XI1_158 BL_ BL WL_158 VSS VDD VSS SIGN_MEMCCOP
XI1_159 BL BL_ WL_159 VSS VDD VSS SIGN_MEMCCOP
XI1_16 BL BL_ WL_16 VSS VDD VSS SIGN_MEMCCOP
XI1_160 BL BL_ WL_160 VSS VDD VSS SIGN_MEMCCOP
XI1_161 BL_ BL WL_161 VSS VDD VSS SIGN_MEMCCOP
XI1_162 BL_ BL WL_162 VSS VDD VSS SIGN_MEMCCOP
XI1_163 BL BL_ WL_163 VSS VDD VSS SIGN_MEMCCOP
XI1_164 BL BL_ WL_164 VSS VDD VSS SIGN_MEMCCOP
XI1_165 BL_ BL WL_165 VSS VDD VSS SIGN_MEMCCOP
XI1_166 BL_ BL WL_166 VSS VDD VSS SIGN_MEMCCOP
XI1_167 BL BL_ WL_167 VSS VDD VSS SIGN_MEMCCOP
XI1_168 BL BL_ WL_168 VSS VDD VSS SIGN_MEMCCOP
XI1_169 BL_ BL WL_169 VSS VDD VSS SIGN_MEMCCOP
XI1_17 BL_ BL WL_17 VSS VDD VSS SIGN_MEMCCOP
XI1_170 BL_ BL WL_170 VSS VDD VSS SIGN_MEMCCOP
XI1_171 BL BL_ WL_171 VSS VDD VSS SIGN_MEMCCOP
XI1_172 BL BL_ WL_172 VSS VDD VSS SIGN_MEMCCOP
XI1_173 BL_ BL WL_173 VSS VDD VSS SIGN_MEMCCOP
XI1_174 BL_ BL WL_174 VSS VDD VSS SIGN_MEMCCOP
XI1_175 BL BL_ WL_175 VSS VDD VSS SIGN_MEMCCOP
XI1_176 BL BL_ WL_176 VSS VDD VSS SIGN_MEMCCOP
XI1_177 BL_ BL WL_177 VSS VDD VSS SIGN_MEMCCOP
XI1_178 BL_ BL WL_178 VSS VDD VSS SIGN_MEMCCOP
XI1_179 BL BL_ WL_179 VSS VDD VSS SIGN_MEMCCOP
XI1_18 BL_ BL WL_18 VSS VDD VSS SIGN_MEMCCOP
XI1_180 BL BL_ WL_180 VSS VDD VSS SIGN_MEMCCOP
XI1_181 BL_ BL WL_181 VSS VDD VSS SIGN_MEMCCOP
XI1_182 BL_ BL WL_182 VSS VDD VSS SIGN_MEMCCOP
XI1_183 BL BL_ WL_183 VSS VDD VSS SIGN_MEMCCOP
XI1_184 BL BL_ WL_184 VSS VDD VSS SIGN_MEMCCOP
XI1_185 BL_ BL WL_185 VSS VDD VSS SIGN_MEMCCOP
XI1_186 BL_ BL WL_186 VSS VDD VSS SIGN_MEMCCOP
XI1_187 BL BL_ WL_187 VSS VDD VSS SIGN_MEMCCOP
XI1_188 BL BL_ WL_188 VSS VDD VSS SIGN_MEMCCOP
XI1_189 BL_ BL WL_189 VSS VDD VSS SIGN_MEMCCOP
XI1_19 BL BL_ WL_19 VSS VDD VSS SIGN_MEMCCOP
XI1_190 BL_ BL WL_190 VSS VDD VSS SIGN_MEMCCOP
XI1_191 BL BL_ WL_191 VSS VDD VSS SIGN_MEMCCOP
XI1_192 BL BL_ WL_192 VSS VDD VSS SIGN_MEMCCOP
XI1_193 BL_ BL WL_193 VSS VDD VSS SIGN_MEMCCOP
XI1_194 BL_ BL WL_194 VSS VDD VSS SIGN_MEMCCOP
XI1_195 BL BL_ WL_195 VSS VDD VSS SIGN_MEMCCOP
XI1_196 BL BL_ WL_196 VSS VDD VSS SIGN_MEMCCOP
XI1_197 BL_ BL WL_197 VSS VDD VSS SIGN_MEMCCOP
XI1_198 BL_ BL WL_198 VSS VDD VSS SIGN_MEMCCOP
XI1_199 BL BL_ WL_199 VSS VDD VSS SIGN_MEMCCOP
XI1_2 BL_ BL WL_2 VSS VDD VSS SIGN_MEMCCOP
XI1_20 BL BL_ WL_20 VSS VDD VSS SIGN_MEMCCOP
XI1_200 BL BL_ WL_200 VSS VDD VSS SIGN_MEMCCOP
XI1_201 BL_ BL WL_201 VSS VDD VSS SIGN_MEMCCOP
XI1_202 BL_ BL WL_202 VSS VDD VSS SIGN_MEMCCOP
XI1_203 BL BL_ WL_203 VSS VDD VSS SIGN_MEMCCOP
XI1_204 BL BL_ WL_204 VSS VDD VSS SIGN_MEMCCOP
XI1_205 BL_ BL WL_205 VSS VDD VSS SIGN_MEMCCOP
XI1_206 BL_ BL WL_206 VSS VDD VSS SIGN_MEMCCOP
XI1_207 BL BL_ WL_207 VSS VDD VSS SIGN_MEMCCOP
XI1_208 BL BL_ WL_208 VSS VDD VSS SIGN_MEMCCOP
XI1_209 BL_ BL WL_209 VSS VDD VSS SIGN_MEMCCOP
XI1_21 BL_ BL WL_21 VSS VDD VSS SIGN_MEMCCOP
XI1_210 BL_ BL WL_210 VSS VDD VSS SIGN_MEMCCOP
XI1_211 BL BL_ WL_211 VSS VDD VSS SIGN_MEMCCOP
XI1_212 BL BL_ WL_212 VSS VDD VSS SIGN_MEMCCOP
XI1_213 BL_ BL WL_213 VSS VDD VSS SIGN_MEMCCOP
XI1_214 BL_ BL WL_214 VSS VDD VSS SIGN_MEMCCOP
XI1_215 BL BL_ WL_215 VSS VDD VSS SIGN_MEMCCOP
XI1_216 BL BL_ WL_216 VSS VDD VSS SIGN_MEMCCOP
XI1_217 BL_ BL WL_217 VSS VDD VSS SIGN_MEMCCOP
XI1_218 BL_ BL WL_218 VSS VDD VSS SIGN_MEMCCOP
XI1_219 BL BL_ WL_219 VSS VDD VSS SIGN_MEMCCOP
XI1_22 BL_ BL WL_22 VSS VDD VSS SIGN_MEMCCOP
XI1_220 BL BL_ WL_220 VSS VDD VSS SIGN_MEMCCOP
XI1_221 BL_ BL WL_221 VSS VDD VSS SIGN_MEMCCOP
XI1_222 BL_ BL WL_222 VSS VDD VSS SIGN_MEMCCOP
XI1_223 BL BL_ WL_223 VSS VDD VSS SIGN_MEMCCOP
XI1_224 BL BL_ WL_224 VSS VDD VSS SIGN_MEMCCOP
XI1_225 BL_ BL WL_225 VSS VDD VSS SIGN_MEMCCOP
XI1_226 BL_ BL WL_226 VSS VDD VSS SIGN_MEMCCOP
XI1_227 BL BL_ WL_227 VSS VDD VSS SIGN_MEMCCOP
XI1_228 BL BL_ WL_228 VSS VDD VSS SIGN_MEMCCOP
XI1_229 BL_ BL WL_229 VSS VDD VSS SIGN_MEMCCOP
XI1_23 BL BL_ WL_23 VSS VDD VSS SIGN_MEMCCOP
XI1_230 BL_ BL WL_230 VSS VDD VSS SIGN_MEMCCOP
XI1_231 BL BL_ WL_231 VSS VDD VSS SIGN_MEMCCOP
XI1_232 BL BL_ WL_232 VSS VDD VSS SIGN_MEMCCOP
XI1_233 BL_ BL WL_233 VSS VDD VSS SIGN_MEMCCOP
XI1_234 BL_ BL WL_234 VSS VDD VSS SIGN_MEMCCOP
XI1_235 BL BL_ WL_235 VSS VDD VSS SIGN_MEMCCOP
XI1_236 BL BL_ WL_236 VSS VDD VSS SIGN_MEMCCOP
XI1_237 BL_ BL WL_237 VSS VDD VSS SIGN_MEMCCOP
XI1_238 BL_ BL WL_238 VSS VDD VSS SIGN_MEMCCOP
XI1_239 BL BL_ WL_239 VSS VDD VSS SIGN_MEMCCOP
XI1_24 BL BL_ WL_24 VSS VDD VSS SIGN_MEMCCOP
XI1_240 BL BL_ WL_240 VSS VDD VSS SIGN_MEMCCOP
XI1_241 BL_ BL WL_241 VSS VDD VSS SIGN_MEMCCOP
XI1_242 BL_ BL WL_242 VSS VDD VSS SIGN_MEMCCOP
XI1_243 BL BL_ WL_243 VSS VDD VSS SIGN_MEMCCOP
XI1_244 BL BL_ WL_244 VSS VDD VSS SIGN_MEMCCOP
XI1_245 BL_ BL WL_245 VSS VDD VSS SIGN_MEMCCOP
XI1_246 BL_ BL WL_246 VSS VDD VSS SIGN_MEMCCOP
XI1_247 BL BL_ WL_247 VSS VDD VSS SIGN_MEMCCOP
XI1_248 BL BL_ WL_248 VSS VDD VSS SIGN_MEMCCOP
XI1_249 BL_ BL WL_249 VSS VDD VSS SIGN_MEMCCOP
XI1_25 BL_ BL WL_25 VSS VDD VSS SIGN_MEMCCOP
XI1_250 BL_ BL WL_250 VSS VDD VSS SIGN_MEMCCOP
XI1_251 BL BL_ WL_251 VSS VDD VSS SIGN_MEMCCOP
XI1_252 BL BL_ WL_252 VSS VDD VSS SIGN_MEMCCOP
XI1_253 BL_ BL WL_253 VSS VDD VSS SIGN_MEMCCOP
XI1_254 BL_ BL WL_254 VSS VDD VSS SIGN_MEMCCOP
XI1_255 BL BL_ WL_255 VSS VDD VSS SIGN_MEMCCOP
XI1_26 BL_ BL WL_26 VSS VDD VSS SIGN_MEMCCOP
XI1_27 BL BL_ WL_27 VSS VDD VSS SIGN_MEMCCOP
XI1_28 BL BL_ WL_28 VSS VDD VSS SIGN_MEMCCOP
XI1_29 BL_ BL WL_29 VSS VDD VSS SIGN_MEMCCOP
XI1_3 BL BL_ WL_3 VSS VDD VSS SIGN_MEMCCOP
XI1_30 BL_ BL WL_30 VSS VDD VSS SIGN_MEMCCOP
XI1_31 BL BL_ WL_31 VSS VDD VSS SIGN_MEMCCOP
XI1_32 BL BL_ WL_32 VSS VDD VSS SIGN_MEMCCOP
XI1_33 BL_ BL WL_33 VSS VDD VSS SIGN_MEMCCOP
XI1_34 BL_ BL WL_34 VSS VDD VSS SIGN_MEMCCOP
XI1_35 BL BL_ WL_35 VSS VDD VSS SIGN_MEMCCOP
XI1_36 BL BL_ WL_36 VSS VDD VSS SIGN_MEMCCOP
XI1_37 BL_ BL WL_37 VSS VDD VSS SIGN_MEMCCOP
XI1_38 BL_ BL WL_38 VSS VDD VSS SIGN_MEMCCOP
XI1_39 BL BL_ WL_39 VSS VDD VSS SIGN_MEMCCOP
XI1_4 BL BL_ WL_4 VSS VDD VSS SIGN_MEMCCOP
XI1_40 BL BL_ WL_40 VSS VDD VSS SIGN_MEMCCOP
XI1_41 BL_ BL WL_41 VSS VDD VSS SIGN_MEMCCOP
XI1_42 BL_ BL WL_42 VSS VDD VSS SIGN_MEMCCOP
XI1_43 BL BL_ WL_43 VSS VDD VSS SIGN_MEMCCOP
XI1_44 BL BL_ WL_44 VSS VDD VSS SIGN_MEMCCOP
XI1_45 BL_ BL WL_45 VSS VDD VSS SIGN_MEMCCOP
XI1_46 BL_ BL WL_46 VSS VDD VSS SIGN_MEMCCOP
XI1_47 BL BL_ WL_47 VSS VDD VSS SIGN_MEMCCOP
XI1_48 BL BL_ WL_48 VSS VDD VSS SIGN_MEMCCOP
XI1_49 BL_ BL WL_49 VSS VDD VSS SIGN_MEMCCOP
XI1_5 BL_ BL WL_5 VSS VDD VSS SIGN_MEMCCOP
XI1_50 BL_ BL WL_50 VSS VDD VSS SIGN_MEMCCOP
XI1_51 BL BL_ WL_51 VSS VDD VSS SIGN_MEMCCOP
XI1_52 BL BL_ WL_52 VSS VDD VSS SIGN_MEMCCOP
XI1_53 BL_ BL WL_53 VSS VDD VSS SIGN_MEMCCOP
XI1_54 BL_ BL WL_54 VSS VDD VSS SIGN_MEMCCOP
XI1_55 BL BL_ WL_55 VSS VDD VSS SIGN_MEMCCOP
XI1_56 BL BL_ WL_56 VSS VDD VSS SIGN_MEMCCOP
XI1_57 BL_ BL WL_57 VSS VDD VSS SIGN_MEMCCOP
XI1_58 BL_ BL WL_58 VSS VDD VSS SIGN_MEMCCOP
XI1_59 BL BL_ WL_59 VSS VDD VSS SIGN_MEMCCOP
XI1_6 BL_ BL WL_6 VSS VDD VSS SIGN_MEMCCOP
XI1_60 BL BL_ WL_60 VSS VDD VSS SIGN_MEMCCOP
XI1_61 BL_ BL WL_61 VSS VDD VSS SIGN_MEMCCOP
XI1_62 BL_ BL WL_62 VSS VDD VSS SIGN_MEMCCOP
XI1_63 BL BL_ WL_63 VSS VDD VSS SIGN_MEMCCOP
XI1_64 BL BL_ WL_64 VSS VDD VSS SIGN_MEMCCOP
XI1_65 BL_ BL WL_65 VSS VDD VSS SIGN_MEMCCOP
XI1_66 BL_ BL WL_66 VSS VDD VSS SIGN_MEMCCOP
XI1_67 BL BL_ WL_67 VSS VDD VSS SIGN_MEMCCOP
XI1_68 BL BL_ WL_68 VSS VDD VSS SIGN_MEMCCOP
XI1_69 BL_ BL WL_69 VSS VDD VSS SIGN_MEMCCOP
XI1_7 BL BL_ WL_7 VSS VDD VSS SIGN_MEMCCOP
XI1_70 BL_ BL WL_70 VSS VDD VSS SIGN_MEMCCOP
XI1_71 BL BL_ WL_71 VSS VDD VSS SIGN_MEMCCOP
XI1_72 BL BL_ WL_72 VSS VDD VSS SIGN_MEMCCOP
XI1_73 BL_ BL WL_73 VSS VDD VSS SIGN_MEMCCOP
XI1_74 BL_ BL WL_74 VSS VDD VSS SIGN_MEMCCOP
XI1_75 BL BL_ WL_75 VSS VDD VSS SIGN_MEMCCOP
XI1_76 BL BL_ WL_76 VSS VDD VSS SIGN_MEMCCOP
XI1_77 BL_ BL WL_77 VSS VDD VSS SIGN_MEMCCOP
XI1_78 BL_ BL WL_78 VSS VDD VSS SIGN_MEMCCOP
XI1_79 BL BL_ WL_79 VSS VDD VSS SIGN_MEMCCOP
XI1_8 BL BL_ WL_8 VSS VDD VSS SIGN_MEMCCOP
XI1_80 BL BL_ WL_80 VSS VDD VSS SIGN_MEMCCOP
XI1_81 BL_ BL WL_81 VSS VDD VSS SIGN_MEMCCOP
XI1_82 BL_ BL WL_82 VSS VDD VSS SIGN_MEMCCOP
XI1_83 BL BL_ WL_83 VSS VDD VSS SIGN_MEMCCOP
XI1_84 BL BL_ WL_84 VSS VDD VSS SIGN_MEMCCOP
XI1_85 BL_ BL WL_85 VSS VDD VSS SIGN_MEMCCOP
XI1_86 BL_ BL WL_86 VSS VDD VSS SIGN_MEMCCOP
XI1_87 BL BL_ WL_87 VSS VDD VSS SIGN_MEMCCOP
XI1_88 BL BL_ WL_88 VSS VDD VSS SIGN_MEMCCOP
XI1_89 BL_ BL WL_89 VSS VDD VSS SIGN_MEMCCOP
XI1_9 BL_ BL WL_9 VSS VDD VSS SIGN_MEMCCOP
XI1_90 BL_ BL WL_90 VSS VDD VSS SIGN_MEMCCOP
XI1_91 BL BL_ WL_91 VSS VDD VSS SIGN_MEMCCOP
XI1_92 BL BL_ WL_92 VSS VDD VSS SIGN_MEMCCOP
XI1_93 BL_ BL WL_93 VSS VDD VSS SIGN_MEMCCOP
XI1_94 BL_ BL WL_94 VSS VDD VSS SIGN_MEMCCOP
XI1_95 BL BL_ WL_95 VSS VDD VSS SIGN_MEMCCOP
XI1_96 BL BL_ WL_96 VSS VDD VSS SIGN_MEMCCOP
XI1_97 BL_ BL WL_97 VSS VDD VSS SIGN_MEMCCOP
XI1_98 BL_ BL WL_98 VSS VDD VSS SIGN_MEMCCOP
XI1_99 BL BL_ WL_99 VSS VDD VSS SIGN_MEMCCOP
XI2_0 NDL NDR_9 WL_0 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_1 NDL NDR_9 WL_1 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_10 NDL_366 NDR_364 WL_10 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_100 NDL_196 NDR_194 WL_100 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_101 NDL_196 NDR_194 WL_101 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_102 NDL_200 NDR_198 WL_102 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_103 NDL_200 NDR_198 WL_103 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_104 NDL_204 NDR_202 WL_104 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_105 NDL_204 NDR_202 WL_105 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_106 NDL_210 NDR_208 WL_106 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_107 NDL_210 NDR_208 WL_107 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_108 NDL_216 NDR_214 WL_108 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_109 NDL_216 NDR_214 WL_109 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_11 NDL_366 NDR_364 WL_11 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_110 NDL_236 NDR_234 WL_110 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_111 NDL_236 NDR_234 WL_111 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_112 NDL_240 NDR_238 WL_112 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_113 NDL_240 NDR_238 WL_113 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_114 NDL_244 NDR_242 WL_114 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_115 NDL_244 NDR_242 WL_115 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_116 NDL_248 NDR_246 WL_116 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_117 NDL_248 NDR_246 WL_117 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_118 NDL_254 NDR_252 WL_118 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_119 NDL_254 NDR_252 WL_119 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_12 NDL_370 NDR_368 WL_12 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_120 NDL_280 NDR_278 WL_120 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_121 NDL_280 NDR_278 WL_121 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_122 NDL_288 NDR_286 WL_122 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_123 NDL_288 NDR_286 WL_123 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_124 NDL_296 NDR_294 WL_124 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_125 NDL_296 NDR_294 WL_125 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_126 NDL_304 NDR_302 WL_126 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_127 NDL_304 NDR_302 WL_127 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_128 NDL_312 NDR_310 WL_128 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_129 NDL_312 NDR_310 WL_129 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_13 NDL_370 NDR_368 WL_13 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_130 NDL_330 NDR_328 WL_130 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_131 NDL_330 NDR_328 WL_131 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_132 NDL_338 NDR_336 WL_132 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_133 NDL_338 NDR_336 WL_133 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_134 NDL_346 NDR_344 WL_134 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_135 NDL_346 NDR_344 WL_135 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_136 NDL_354 NDR_352 WL_136 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_137 NDL_354 NDR_352 WL_137 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_138 NDL_362 NDR_360 WL_138 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_139 NDL_362 NDR_360 WL_139 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_14 NDL_376 NDR_374 WL_14 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_140 NDL_400 NDR_398 WL_140 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_141 NDL_400 NDR_398 WL_141 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_142 NDL_408 NDR_406 WL_142 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_143 NDL_408 NDR_406 WL_143 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_144 NDL_416 NDR_414 WL_144 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_145 NDL_416 NDR_414 WL_145 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_146 NDL_424 NDR_422 WL_146 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_147 NDL_424 NDR_422 WL_147 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_148 NDL_432 NDR_430 WL_148 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_149 NDL_432 NDR_430 WL_149 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_15 NDL_376 NDR_374 WL_15 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_150 NDL_470 NDR_468 WL_150 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_151 NDL_470 NDR_468 WL_151 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_152 NDL_478 NDR_476 WL_152 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_153 NDL_478 NDR_476 WL_153 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_154 NDL_486 NDR_484 WL_154 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_155 NDL_486 NDR_484 WL_155 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_156 NDL_494 NDR_492 WL_156 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_157 NDL_494 NDR_492 WL_157 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_158 NDL_502 NDR_500 WL_158 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_159 NDL_502 NDR_500 WL_159 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_16 NDL_382 NDR_380 WL_16 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_160 NDL_540 NDR_538 WL_160 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_161 NDL_540 NDR_538 WL_161 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_162 NDL_548 NDR_546 WL_162 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_163 NDL_548 NDR_546 WL_163 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_164 NDL_556 NDR_554 WL_164 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_165 NDL_556 NDR_554 WL_165 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_166 NDL_564 NDR_562 WL_166 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_167 NDL_564 NDR_562 WL_167 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_168 NDL_572 NDR_570 WL_168 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_169 NDL_572 NDR_570 WL_169 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_17 NDL_382 NDR_380 WL_17 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_170 NDL_600 NDR_598 WL_170 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_171 NDL_600 NDR_598 WL_171 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_172 NDL_608 NDR_606 WL_172 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_173 NDL_608 NDR_606 WL_173 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_174 NDL_616 NDR_614 WL_174 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_175 NDL_616 NDR_614 WL_175 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_176 NDL_620 NDR_618 WL_176 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_177 NDL_620 NDR_618 WL_177 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_178 NDL_626 NDR_624 WL_178 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_179 NDL_626 NDR_624 WL_179 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_18 NDL_388 NDR_386 WL_18 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_180 NDL_650 NDR_648 WL_180 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_181 NDL_650 NDR_648 WL_181 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_182 NDL_654 NDR_652 WL_182 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_183 NDL_654 NDR_652 WL_183 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_184 NDL_658 NDR_656 WL_184 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_185 NDL_658 NDR_656 WL_185 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_186 NDL_662 NDR_660 WL_186 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_187 NDL_662 NDR_660 WL_187 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_188 NDL_666 NDR_664 WL_188 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_189 NDL_666 NDR_664 WL_189 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_19 NDL_388 NDR_386 WL_19 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_190 NDL_690 NDR_688 WL_190 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_191 NDL_690 NDR_688 WL_191 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_192 NDL_694 NDR_692 WL_192 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_193 NDL_694 NDR_692 WL_193 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_194 NDL_698 NDR_696 WL_194 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_195 NDL_698 NDR_696 WL_195 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_196 NDL_702 NDR_700 WL_196 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_197 NDL_702 NDR_700 WL_197 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_198 NDL_706 NDR_704 WL_198 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_199 NDL_706 NDR_704 WL_199 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_2 NDL_14 NDR_12 WL_2 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_20 NDL_436 NDR_434 WL_20 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_200 NDL_276 NDR_274 WL_200 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_201 NDL_276 NDR_274 WL_201 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_202 NDL_284 NDR_282 WL_202 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_203 NDL_284 NDR_282 WL_203 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_204 NDL_292 NDR_290 WL_204 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_205 NDL_292 NDR_290 WL_205 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_206 NDL_300 NDR_298 WL_206 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_207 NDL_300 NDR_298 WL_207 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_208 NDL_308 NDR_306 WL_208 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_209 NDL_308 NDR_306 WL_209 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_21 NDL_436 NDR_434 WL_21 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_210 NDL_326 NDR_324 WL_210 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_211 NDL_326 NDR_324 WL_211 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_212 NDL_334 NDR_332 WL_212 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_213 NDL_334 NDR_332 WL_213 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_214 NDL_342 NDR_340 WL_214 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_215 NDL_342 NDR_340 WL_215 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_216 NDL_350 NDR_348 WL_216 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_217 NDL_350 NDR_348 WL_217 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_218 NDL_358 NDR_356 WL_218 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_219 NDL_358 NDR_356 WL_219 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_22 NDL_440 NDR_438 WL_22 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_220 NDL_396 NDR_394 WL_220 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_221 NDL_396 NDR_394 WL_221 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_222 NDL_404 NDR_402 WL_222 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_223 NDL_404 NDR_402 WL_223 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_224 NDL_412 NDR_410 WL_224 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_225 NDL_412 NDR_410 WL_225 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_226 NDL_420 NDR_418 WL_226 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_227 NDL_420 NDR_418 WL_227 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_228 NDL_428 NDR_426 WL_228 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_229 NDL_428 NDR_426 WL_229 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_23 NDL_440 NDR_438 WL_23 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_230 NDL_466 NDR_464 WL_230 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_231 NDL_466 NDR_464 WL_231 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_232 NDL_474 NDR_472 WL_232 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_233 NDL_474 NDR_472 WL_233 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_234 NDL_482 NDR_480 WL_234 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_235 NDL_482 NDR_480 WL_235 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_236 NDL_490 NDR_488 WL_236 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_237 NDL_490 NDR_488 WL_237 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_238 NDL_498 NDR_496 WL_238 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_239 NDL_498 NDR_496 WL_239 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_24 NDL_446 NDR_444 WL_24 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_240 NDL_536 NDR_534 WL_240 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_241 NDL_536 NDR_534 WL_241 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_242 NDL_544 NDR_542 WL_242 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_243 NDL_544 NDR_542 WL_243 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_244 NDL_552 NDR_550 WL_244 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_245 NDL_552 NDR_550 WL_245 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_246 NDL_560 NDR_558 WL_246 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_247 NDL_560 NDR_558 WL_247 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_248 NDL_568 NDR_566 WL_248 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_249 NDL_568 NDR_566 WL_249 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_25 NDL_446 NDR_444 WL_25 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_250 NDL_596 NDR_594 WL_250 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_251 NDL_596 NDR_594 WL_251 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_252 NDL_604 NDR_602 WL_252 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_253 NDL_604 NDR_602 WL_253 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_254 NDL_612 NDR_610 WL_254 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_255 NDL_612 NDR_610 WL_255 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_257 NDR_622 WL_256 VDD VSS SIGN_MEMFLCCMBLSTU
XI2_258 NDR_622 WL_257 VDD VSS SIGN_MEMFLCCMBLSTU
XI2_26 NDL_450 NDR_448 WL_26 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_27 NDL_450 NDR_448 WL_27 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_28 NDL_456 NDR_454 WL_28 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_29 NDL_456 NDR_454 WL_29 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_3 NDL_14 NDR_12 WL_3 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_30 NDL_506 NDR_504 WL_30 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_31 NDL_506 NDR_504 WL_31 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_32 NDL_510 NDR_508 WL_32 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_33 NDL_510 NDR_508 WL_33 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_34 NDL_514 NDR_512 WL_34 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_35 NDL_514 NDR_512 WL_35 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_36 NDL_520 NDR_518 WL_36 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_37 NDL_520 NDR_518 WL_37 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_38 NDL_526 NDR_524 WL_38 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_39 NDL_526 NDR_524 WL_39 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_4 NDL_18 NDR_16 WL_4 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_40 NDL_576 NDR_574 WL_40 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_41 NDL_576 NDR_574 WL_41 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_42 NDL_580 NDR_578 WL_42 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_43 NDL_580 NDR_578 WL_43 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_44 NDL_584 NDR_582 WL_44 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_45 NDL_584 NDR_582 WL_45 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_46 NDL_588 NDR_586 WL_46 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_47 NDL_588 NDR_586 WL_47 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_48 NDL_592 NDR_590 WL_48 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_49 NDL_592 NDR_590 WL_49 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_5 NDL_18 NDR_16 WL_5 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_50 NDL_630 NDR_628 WL_50 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_51 NDL_630 NDR_628 WL_51 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_52 NDL_634 NDR_632 WL_52 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_53 NDL_634 NDR_632 WL_53 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_54 NDL_638 NDR_636 WL_54 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_55 NDL_638 NDR_636 WL_55 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_56 NDL_642 NDR_640 WL_56 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_57 NDL_642 NDR_640 WL_57 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_58 NDL_646 NDR_644 WL_58 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_59 NDL_646 NDR_644 WL_59 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_6 NDL_22 NDR_20 WL_6 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_60 NDL_670 NDR_668 WL_60 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_61 NDL_670 NDR_668 WL_61 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_62 NDL_674 NDR_672 WL_62 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_63 NDL_674 NDR_672 WL_63 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_64 NDL_678 NDR_676 WL_64 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_65 NDL_678 NDR_676 WL_65 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_66 NDL_682 NDR_680 WL_66 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_67 NDL_682 NDR_680 WL_67 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_68 NDL_686 NDR_684 WL_68 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_69 NDL_686 NDR_684 WL_69 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_7 NDL_22 NDR_20 WL_7 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_70 NDL_710 NDR_708 WL_70 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_71 NDL_710 NDR_708 WL_71 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_72 NDL_714 NDR_712 WL_72 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_73 NDL_714 NDR_712 WL_73 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_74 NDL_718 NDR_716 WL_74 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_75 NDL_718 NDR_716 WL_75 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_76 NDL_722 NDR_720 WL_76 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_77 NDL_722 NDR_720 WL_77 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_78 NDL_726 NDR_724 WL_78 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_79 NDL_726 NDR_724 WL_79 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_8 NDL_26 NDR_24 WL_8 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_80 NDL_730 NDR_728 WL_80 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_81 NDL_730 NDR_728 WL_81 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_82 NDL_734 NDR_732 WL_82 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_83 NDL_734 NDR_732 WL_83 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_84 NDL_738 NDR_736 WL_84 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_85 NDL_738 NDR_736 WL_85 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_86 NDL_742 NDR_740 WL_86 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_87 NDL_742 NDR_740 WL_87 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_88 NDL_746 NDR_744 WL_88 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_89 NDL_746 NDR_744 WL_89 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_9 NDL_26 NDR_24 WL_9 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_90 NDL_750 NDR_748 WL_90 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_91 NDL_750 NDR_748 WL_91 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_92 NDL_754 NDR_752 WL_92 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_93 NDL_754 NDR_752 WL_93 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_94 NDL_758 NDR_756 WL_94 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_95 NDL_758 NDR_756 WL_95 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_96 NDL_762 NDR_760 WL_96 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_97 NDL_762 NDR_760 WL_97 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_98 NDL_766 NDR_764 WL_98 VSS VDD VSS SIGN_MEMFLCCMBLST
XI2_99 NDL_766 NDR_764 WL_99 VSS VDD VSS SIGN_MEMFLCCMBLST
.ENDS SIGN_MEMMODEL_COL
****
.SUBCKT SIGN_MEMFLMWEG BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VDD VSS
** SIGN_MEMFLMWEG: 24 flat devices **
m1 N11 WP1 BL0 VSS LPNFET L=0.13U W=0.16U
m10 N13 N14 VSS VSS LPNFET L=0.1U W=0.2U
m11 N18 WP3 BL1_ VSS LPNFET L=0.13U W=0.16U
m12 N17 N18 VDD VDD LPPFET L=0.12U W=0.15U
m13 N17 N18 VSS VSS LPNFET L=0.1U W=0.2U
m14 N18 N17 VDD VDD LPPFET L=0.12U W=0.15U
m15 N18 N17 VSS VSS LPNFET L=0.1U W=0.2U
m16 N16 WP2 BL1_ VSS LPNFET L=0.13U W=0.16U
m17 N15 N16 VDD VDD LPPFET L=0.12U W=0.15U
m18 N15 N16 VSS VSS LPNFET L=0.1U W=0.2U
m19 N16 N15 VDD VDD LPPFET L=0.12U W=0.15U
m2 N12 N11 VDD VDD LPPFET L=0.12U W=0.15U
m20 N16 N15 VSS VSS LPNFET L=0.1U W=0.2U
m21 N12 WP3 BL0_ VSS LPNFET L=0.13U W=0.16U
m22 N14 WP2 BL0_ VSS LPNFET L=0.13U W=0.16U
m23 N17 WP3 BL1 VSS LPNFET L=0.13U W=0.16U
m24 N15 WP2 BL1 VSS LPNFET L=0.13U W=0.16U
m3 N12 N11 VSS VSS LPNFET L=0.1U W=0.2U
m4 N11 N12 VDD VDD LPPFET L=0.12U W=0.15U
m5 N11 N12 VSS VSS LPNFET L=0.1U W=0.2U
m6 N13 WP0 BL0 VSS LPNFET L=0.13U W=0.16U
m7 N14 N13 VDD VDD LPPFET L=0.12U W=0.15U
m8 N14 N13 VSS VSS LPNFET L=0.1U W=0.2U
m9 N13 N14 VDD VDD LPPFET L=0.12U W=0.15U
.ENDS SIGN_MEMFLMWEG
****
.SUBCKT SIGN_MEMMROW_8_RIGHT BL0 BL0_ BL1 BL1_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 WL VDD VSS
** SIGN_MEMMROW_8_RIGHT: 1548 flat devices **
XI0_0 BL_0 BL__0 WL WL VDD VSS SIGN_MEMCCEG
XI0_1 BL__0 BL_0 WL WL VDD VSS SIGN_MEMCCEG
XI100_0 BL_95 BL__95 VSS VSS VDD VSS SIGN_MEMCCOP
XI100_1 BL__95 BL_95 VSS VSS VDD VSS SIGN_MEMCCOP
XI101_0 BL_96 BL__96 VSS VSS VDD VSS SIGN_MEMCCEP
XI101_1 BL__96 BL_96 VSS VSS VDD VSS SIGN_MEMCCEP
XI102_0 BL_97 BL__97 VSS VSS VDD VSS SIGN_MEMCCOG
XI102_1 BL__97 BL_97 VSS VSS VDD VSS SIGN_MEMCCOG
XI103_0 BL_98 BL__98 VSS VSS VDD VSS SIGN_MEMCCEG
XI103_1 BL__98 BL_98 VSS VSS VDD VSS SIGN_MEMCCEG
XI104_0 BL_99 BL__99 VSS VSS VDD VSS SIGN_MEMCCOP
XI104_1 BL__99 BL_99 VSS VSS VDD VSS SIGN_MEMCCOP
XI105_0 BL_100 BL__100 VSS VSS VDD VSS SIGN_MEMCCEP
XI105_1 BL__100 BL_100 VSS VSS VDD VSS SIGN_MEMCCEP
XI106_0 BL_101 BL__101 VSS VSS VDD VSS SIGN_MEMCCOG
XI106_1 BL__101 BL_101 VSS VSS VDD VSS SIGN_MEMCCOG
XI107_0 BL_102 BL__102 VSS VSS VDD VSS SIGN_MEMCCEG
XI107_1 BL__102 BL_102 VSS VSS VDD VSS SIGN_MEMCCEG
XI108_0 BL_103 BL__103 VSS VSS VDD VSS SIGN_MEMCCOP
XI108_1 BL__103 BL_103 VSS VSS VDD VSS SIGN_MEMCCOP
XI109_0 BL_104 BL__104 VSS VSS VDD VSS SIGN_MEMCCEP
XI109_1 BL__104 BL_104 VSS VSS VDD VSS SIGN_MEMCCEP
XI10_0 BL_10 BL__10 WL WL VDD VSS SIGN_MEMCCEP
XI10_1 BL__10 BL_10 WL WL VDD VSS SIGN_MEMCCEP
XI110_0 BL_105 BL__105 VSS VSS VDD VSS SIGN_MEMCCOG
XI110_1 BL__105 BL_105 VSS VSS VDD VSS SIGN_MEMCCOG
XI111_0 BL_106 BL__106 VSS VSS VDD VSS SIGN_MEMCCEG
XI111_1 BL__106 BL_106 VSS VSS VDD VSS SIGN_MEMCCEG
XI112_0 BL_107 BL__107 VSS VSS VDD VSS SIGN_MEMCCOP
XI112_1 BL__107 BL_107 VSS VSS VDD VSS SIGN_MEMCCOP
XI113_0 BL_108 BL__108 VSS VSS VDD VSS SIGN_MEMCCEP
XI113_1 BL__108 BL_108 VSS VSS VDD VSS SIGN_MEMCCEP
XI114_0 BL_109 BL__109 VSS VSS VDD VSS SIGN_MEMCCOG
XI114_1 BL__109 BL_109 VSS VSS VDD VSS SIGN_MEMCCOG
XI115_0 BL_110 BL__110 VSS VSS VDD VSS SIGN_MEMCCEG
XI115_1 BL__110 BL_110 VSS VSS VDD VSS SIGN_MEMCCEG
XI116_0 BL_111 BL__111 VSS VSS VDD VSS SIGN_MEMCCOP
XI116_1 BL__111 BL_111 VSS VSS VDD VSS SIGN_MEMCCOP
XI117_0 BL_112 BL__112 VSS VSS VDD VSS SIGN_MEMCCEP
XI117_1 BL__112 BL_112 VSS VSS VDD VSS SIGN_MEMCCEP
XI118_0 BL_113 BL__113 VSS VSS VDD VSS SIGN_MEMCCOG
XI118_1 BL__113 BL_113 VSS VSS VDD VSS SIGN_MEMCCOG
XI119_0 BL_114 BL__114 VSS VSS VDD VSS SIGN_MEMCCEG
XI119_1 BL__114 BL_114 VSS VSS VDD VSS SIGN_MEMCCEG
XI11_0 BL_11 BL__11 WL WL VDD VSS SIGN_MEMCCOG
XI11_1 BL__11 BL_11 WL WL VDD VSS SIGN_MEMCCOG
XI120_0 BL_115 BL__115 VSS VSS VDD VSS SIGN_MEMCCOP
XI120_1 BL__115 BL_115 VSS VSS VDD VSS SIGN_MEMCCOP
XI121_0 BL_116 BL__116 VSS VSS VDD VSS SIGN_MEMCCEP
XI121_1 BL__116 BL_116 VSS VSS VDD VSS SIGN_MEMCCEP
XI122_0 BL_117 BL__117 VSS VSS VDD VSS SIGN_MEMCCOG
XI122_1 BL__117 BL_117 VSS VSS VDD VSS SIGN_MEMCCOG
XI123_0 BL_118 BL__118 VSS VSS VDD VSS SIGN_MEMCCEG
XI123_1 BL__118 BL_118 VSS VSS VDD VSS SIGN_MEMCCEG
XI124_0 BL_119 BL__119 VSS VSS VDD VSS SIGN_MEMCCOP
XI124_1 BL__119 BL_119 VSS VSS VDD VSS SIGN_MEMCCOP
XI125_0 BL_120 BL__120 VSS VSS VDD VSS SIGN_MEMCCEP
XI125_1 BL__120 BL_120 VSS VSS VDD VSS SIGN_MEMCCEP
XI126_0 BL_121 BL__121 VSS VSS VDD VSS SIGN_MEMCCOG
XI126_1 BL__121 BL_121 VSS VSS VDD VSS SIGN_MEMCCOG
XI127_0 BL_122 BL__122 VSS VSS VDD VSS SIGN_MEMCCEG
XI127_1 BL__122 BL_122 VSS VSS VDD VSS SIGN_MEMCCEG
XI128_0 BL_123 BL__123 VSS VSS VDD VSS SIGN_MEMCCOP
XI128_1 BL__123 BL_123 VSS VSS VDD VSS SIGN_MEMCCOP
XI129_0 BL_124 BL__124 VSS VSS VDD VSS SIGN_MEMCCEP
XI129_1 BL__124 BL_124 VSS VSS VDD VSS SIGN_MEMCCEP
XI12_0 BL_12 BL__12 WL WL VDD VSS SIGN_MEMCCEG
XI12_1 BL__12 BL_12 WL WL VDD VSS SIGN_MEMCCEG
XI130_0 BL_125 BL__125 VSS VSS VDD VSS SIGN_MEMCCOG
XI130_1 BL__125 BL_125 VSS VSS VDD VSS SIGN_MEMCCOG
XI13_0 BL_13 BL__13 WL WL VDD VSS SIGN_MEMCCOP
XI13_1 BL__13 BL_13 WL WL VDD VSS SIGN_MEMCCOP
XI14_0 BL_14 BL__14 WL WL VDD VSS SIGN_MEMCCEP
XI14_1 BL__14 BL_14 WL WL VDD VSS SIGN_MEMCCEP
XI15_0 BL_15 BL__15 WL WL VDD VSS SIGN_MEMCCOG
XI15_1 BL__15 BL_15 WL WL VDD VSS SIGN_MEMCCOG
XI16_0 BL_16 BL__16 WL WL VDD VSS SIGN_MEMCCEG
XI16_1 BL__16 BL_16 WL WL VDD VSS SIGN_MEMCCEG
XI17_0 BL_17 BL__17 WL WL VDD VSS SIGN_MEMCCOP
XI17_1 BL__17 BL_17 WL WL VDD VSS SIGN_MEMCCOP
XI18_0 BL_18 BL__18 WL WL VDD VSS SIGN_MEMCCEP
XI18_1 BL__18 BL_18 WL WL VDD VSS SIGN_MEMCCEP
XI19_0 BL_19 BL__19 WL WL VDD VSS SIGN_MEMCCOG
XI19_1 BL__19 BL_19 WL WL VDD VSS SIGN_MEMCCOG
XI1_0 BL_1 BL__1 WL WL VDD VSS SIGN_MEMCCOP
XI1_1 BL__1 BL_1 WL WL VDD VSS SIGN_MEMCCOP
XI20_0 BL_20 BL__20 WL WL VDD VSS SIGN_MEMCCEG
XI20_1 BL__20 BL_20 WL WL VDD VSS SIGN_MEMCCEG
XI21_0 BL_21 BL__21 WL WL VDD VSS SIGN_MEMCCOP
XI21_1 BL__21 BL_21 WL WL VDD VSS SIGN_MEMCCOP
XI22_0 BL_22 BL__22 WL WL VDD VSS SIGN_MEMCCEP
XI22_1 BL__22 BL_22 WL WL VDD VSS SIGN_MEMCCEP
XI23_0 BL_23 BL__23 WL WL VDD VSS SIGN_MEMCCOG
XI23_1 BL__23 BL_23 WL WL VDD VSS SIGN_MEMCCOG
XI24_0 BL_24 BL__24 WL WL VDD VSS SIGN_MEMCCEG
XI24_1 BL__24 BL_24 WL WL VDD VSS SIGN_MEMCCEG
XI25_0 BL_25 BL__25 WL WL VDD VSS SIGN_MEMCCOP
XI25_1 BL__25 BL_25 WL WL VDD VSS SIGN_MEMCCOP
XI26_0 BL_26 BL__26 WL WL VDD VSS SIGN_MEMCCEP
XI26_1 BL__26 BL_26 WL WL VDD VSS SIGN_MEMCCEP
XI27_0 BL_27 BL__27 WL WL VDD VSS SIGN_MEMCCOG
XI27_1 BL__27 BL_27 WL WL VDD VSS SIGN_MEMCCOG
XI28_0 BL_28 BL__28 WL WL VDD VSS SIGN_MEMCCEG
XI28_1 BL__28 BL_28 WL WL VDD VSS SIGN_MEMCCEG
XI29_0 BL_29 BL__29 WL WL VDD VSS SIGN_MEMCCOP
XI29_1 BL__29 BL_29 WL WL VDD VSS SIGN_MEMCCOP
XI2_0 BL_2 BL__2 WL WL VDD VSS SIGN_MEMCCEP
XI2_1 BL__2 BL_2 WL WL VDD VSS SIGN_MEMCCEP
XI30_0 BL_30 BL__30 WL WL VDD VSS SIGN_MEMCCEP
XI30_1 BL__30 BL_30 WL WL VDD VSS SIGN_MEMCCEP
XI31_0 BL_31 BL__31 WL WL VDD VSS SIGN_MEMCCOG
XI31_1 BL__31 BL_31 WL WL VDD VSS SIGN_MEMCCOG
XI32_0 NDL_8 NDR_6 WL VDD VSS SIGN_MEMFLCCSTRAP
XI32_1 NDL_8 NDR_6 WL VDD VSS SIGN_MEMFLCCSTRAP
XI33_0 BL_32 BL__32 WL WL VDD VSS SIGN_MEMCCEG
XI33_1 BL__32 BL_32 WL WL VDD VSS SIGN_MEMCCEG
XI34_0 BL_33 BL__33 WL WL VDD VSS SIGN_MEMCCOP
XI34_1 BL__33 BL_33 WL WL VDD VSS SIGN_MEMCCOP
XI35_0 BL_34 BL__34 WL WL VDD VSS SIGN_MEMCCEP
XI35_1 BL__34 BL_34 WL WL VDD VSS SIGN_MEMCCEP
XI36_0 BL_35 BL__35 WL WL VDD VSS SIGN_MEMCCOG
XI36_1 BL__35 BL_35 WL WL VDD VSS SIGN_MEMCCOG
XI37_0 BL_36 BL__36 WL WL VDD VSS SIGN_MEMCCEG
XI37_1 BL__36 BL_36 WL WL VDD VSS SIGN_MEMCCEG
XI38_0 BL_37 BL__37 WL WL VDD VSS SIGN_MEMCCOP
XI38_1 BL__37 BL_37 WL WL VDD VSS SIGN_MEMCCOP
XI39_0 BL_38 BL__38 WL WL VDD VSS SIGN_MEMCCEP
XI39_1 BL__38 BL_38 WL WL VDD VSS SIGN_MEMCCEP
XI3_0 BL_3 BL__3 WL WL VDD VSS SIGN_MEMCCOG
XI3_1 BL__3 BL_3 WL WL VDD VSS SIGN_MEMCCOG
XI40_0 BL_39 BL__39 WL WL VDD VSS SIGN_MEMCCOG
XI40_1 BL__39 BL_39 WL WL VDD VSS SIGN_MEMCCOG
XI41_0 BL_40 BL__40 WL WL VDD VSS SIGN_MEMCCEG
XI41_1 BL__40 BL_40 WL WL VDD VSS SIGN_MEMCCEG
XI42_0 BL_41 BL__41 WL WL VDD VSS SIGN_MEMCCOP
XI42_1 BL__41 BL_41 WL WL VDD VSS SIGN_MEMCCOP
XI43_0 BL_42 BL__42 WL WL VDD VSS SIGN_MEMCCEP
XI43_1 BL__42 BL_42 WL WL VDD VSS SIGN_MEMCCEP
XI44_0 BL_43 BL__43 WL WL VDD VSS SIGN_MEMCCOG
XI44_1 BL__43 BL_43 WL WL VDD VSS SIGN_MEMCCOG
XI45_0 BL_44 BL__44 WL WL VDD VSS SIGN_MEMCCEG
XI45_1 BL__44 BL_44 WL WL VDD VSS SIGN_MEMCCEG
XI46_0 BL_45 BL__45 WL WL VDD VSS SIGN_MEMCCOP
XI46_1 BL__45 BL_45 WL WL VDD VSS SIGN_MEMCCOP
XI47_0 BL_46 BL__46 WL WL VDD VSS SIGN_MEMCCEP
XI47_1 BL__46 BL_46 WL WL VDD VSS SIGN_MEMCCEP
XI48_0 BL_47 BL__47 WL WL VDD VSS SIGN_MEMCCOG
XI48_1 BL__47 BL_47 WL WL VDD VSS SIGN_MEMCCOG
XI49_0 BL_48 BL__48 WL WL VDD VSS SIGN_MEMCCEG
XI49_1 BL__48 BL_48 WL WL VDD VSS SIGN_MEMCCEG
XI4_0 BL_4 BL__4 WL WL VDD VSS SIGN_MEMCCEG
XI4_1 BL__4 BL_4 WL WL VDD VSS SIGN_MEMCCEG
XI50_0 BL_49 BL__49 WL WL VDD VSS SIGN_MEMCCOP
XI50_1 BL__49 BL_49 WL WL VDD VSS SIGN_MEMCCOP
XI51_0 BL_50 BL__50 WL WL VDD VSS SIGN_MEMCCEP
XI51_1 BL__50 BL_50 WL WL VDD VSS SIGN_MEMCCEP
XI52_0 BL_51 BL__51 WL WL VDD VSS SIGN_MEMCCOG
XI52_1 BL__51 BL_51 WL WL VDD VSS SIGN_MEMCCOG
XI53_0 BL_52 BL__52 WL WL VDD VSS SIGN_MEMCCEG
XI53_1 BL__52 BL_52 WL WL VDD VSS SIGN_MEMCCEG
XI54_0 BL_53 BL__53 WL WL VDD VSS SIGN_MEMCCOP
XI54_1 BL__53 BL_53 WL WL VDD VSS SIGN_MEMCCOP
XI55_0 BL_54 BL__54 WL WL VDD VSS SIGN_MEMCCEP
XI55_1 BL__54 BL_54 WL WL VDD VSS SIGN_MEMCCEP
XI56_0 BL_55 BL__55 WL WL VDD VSS SIGN_MEMCCOG
XI56_1 BL__55 BL_55 WL WL VDD VSS SIGN_MEMCCOG
XI57_0 BL_56 BL__56 WL WL VDD VSS SIGN_MEMCCEG
XI57_1 BL__56 BL_56 WL WL VDD VSS SIGN_MEMCCEG
XI58_0 BL_57 BL__57 WL WL VDD VSS SIGN_MEMCCOP
XI58_1 BL__57 BL_57 WL WL VDD VSS SIGN_MEMCCOP
XI59_0 BL_58 BL__58 WL WL VDD VSS SIGN_MEMCCEP
XI59_1 BL__58 BL_58 WL WL VDD VSS SIGN_MEMCCEP
XI5_0 BL_5 BL__5 WL WL VDD VSS SIGN_MEMCCOP
XI5_1 BL__5 BL_5 WL WL VDD VSS SIGN_MEMCCOP
XI60_0 BL_59 BL__59 WL WL VDD VSS SIGN_MEMCCOG
XI60_1 BL__59 BL_59 WL WL VDD VSS SIGN_MEMCCOG
XI61_0 BL_60 BL__60 WL WL VDD VSS SIGN_MEMCCEG
XI61_1 BL__60 BL_60 WL WL VDD VSS SIGN_MEMCCEG
XI62_0 BL_61 BL__61 WL WL VDD VSS SIGN_MEMCCOP
XI62_1 BL__61 BL_61 WL WL VDD VSS SIGN_MEMCCOP
XI63_0 BL_62 BL__62 WL WL VDD VSS SIGN_MEMCCEP
XI63_1 BL__62 BL_62 WL WL VDD VSS SIGN_MEMCCEP
XI64_0 BL_63 BL__63 WL WL VDD VSS SIGN_MEMCCOG
XI64_1 BL__63 BL_63 WL WL VDD VSS SIGN_MEMCCOG
XI65_0 NDL_4 NDR_2 WL VDD VSS SIGN_MEMFLCCSTRAP
XI65_1 NDL_4 NDR_2 WL VDD VSS SIGN_MEMFLCCSTRAP
XI66_0 BL0 BL0_ BL1 BL1_ WL WL WL VSS VSS VDD VSS SIGN_MEMFLMWEG
XI68_0 BL_64 BL__64 VSS VSS VDD VSS SIGN_MEMCCEP
XI68_1 BL__64 BL_64 VSS VSS VDD VSS SIGN_MEMCCEP
XI69_0 BL_65 BL__65 VSS VSS VDD VSS SIGN_MEMCCOG
XI69_1 BL__65 BL_65 VSS VSS VDD VSS SIGN_MEMCCOG
XI6_0 BL_6 BL__6 WL WL VDD VSS SIGN_MEMCCEP
XI6_1 BL__6 BL_6 WL WL VDD VSS SIGN_MEMCCEP
XI70_0 BL_66 BL__66 VSS VSS VDD VSS SIGN_MEMCCEG
XI70_1 BL__66 BL_66 VSS VSS VDD VSS SIGN_MEMCCEG
XI71_0 BL_67 BL__67 VSS VSS VDD VSS SIGN_MEMCCOP
XI71_1 BL__67 BL_67 VSS VSS VDD VSS SIGN_MEMCCOP
XI72_0 BL_68 BL__68 VSS VSS VDD VSS SIGN_MEMCCEP
XI72_1 BL__68 BL_68 VSS VSS VDD VSS SIGN_MEMCCEP
XI73_0 BL_69 BL__69 VSS VSS VDD VSS SIGN_MEMCCOG
XI73_1 BL__69 BL_69 VSS VSS VDD VSS SIGN_MEMCCOG
XI74_0 BL_70 BL__70 VSS VSS VDD VSS SIGN_MEMCCEG
XI74_1 BL__70 BL_70 VSS VSS VDD VSS SIGN_MEMCCEG
XI75_0 BL_71 BL__71 VSS VSS VDD VSS SIGN_MEMCCOP
XI75_1 BL__71 BL_71 VSS VSS VDD VSS SIGN_MEMCCOP
XI76_0 BL_72 BL__72 VSS VSS VDD VSS SIGN_MEMCCEP
XI76_1 BL__72 BL_72 VSS VSS VDD VSS SIGN_MEMCCEP
XI77_0 BL_73 BL__73 VSS VSS VDD VSS SIGN_MEMCCOG
XI77_1 BL__73 BL_73 VSS VSS VDD VSS SIGN_MEMCCOG
XI78_0 BL_74 BL__74 VSS VSS VDD VSS SIGN_MEMCCEG
XI78_1 BL__74 BL_74 VSS VSS VDD VSS SIGN_MEMCCEG
XI79_0 BL_75 BL__75 VSS VSS VDD VSS SIGN_MEMCCOP
XI79_1 BL__75 BL_75 VSS VSS VDD VSS SIGN_MEMCCOP
XI7_0 BL_7 BL__7 WL WL VDD VSS SIGN_MEMCCOG
XI7_1 BL__7 BL_7 WL WL VDD VSS SIGN_MEMCCOG
XI80_0 BL_76 BL__76 VSS VSS VDD VSS SIGN_MEMCCEP
XI80_1 BL__76 BL_76 VSS VSS VDD VSS SIGN_MEMCCEP
XI81_0 BL_77 BL__77 VSS VSS VDD VSS SIGN_MEMCCOG
XI81_1 BL__77 BL_77 VSS VSS VDD VSS SIGN_MEMCCOG
XI82_0 BL_78 BL__78 VSS VSS VDD VSS SIGN_MEMCCEG
XI82_1 BL__78 BL_78 VSS VSS VDD VSS SIGN_MEMCCEG
XI83_0 BL_79 BL__79 VSS VSS VDD VSS SIGN_MEMCCOP
XI83_1 BL__79 BL_79 VSS VSS VDD VSS SIGN_MEMCCOP
XI84_0 BL_80 BL__80 VSS VSS VDD VSS SIGN_MEMCCEP
XI84_1 BL__80 BL_80 VSS VSS VDD VSS SIGN_MEMCCEP
XI85_0 BL_81 BL__81 VSS VSS VDD VSS SIGN_MEMCCOG
XI85_1 BL__81 BL_81 VSS VSS VDD VSS SIGN_MEMCCOG
XI86_0 BL_82 BL__82 VSS VSS VDD VSS SIGN_MEMCCEG
XI86_1 BL__82 BL_82 VSS VSS VDD VSS SIGN_MEMCCEG
XI87_0 BL_83 BL__83 VSS VSS VDD VSS SIGN_MEMCCOP
XI87_1 BL__83 BL_83 VSS VSS VDD VSS SIGN_MEMCCOP
XI88_0 BL_84 BL__84 VSS VSS VDD VSS SIGN_MEMCCEP
XI88_1 BL__84 BL_84 VSS VSS VDD VSS SIGN_MEMCCEP
XI89_0 BL_85 BL__85 VSS VSS VDD VSS SIGN_MEMCCOG
XI89_1 BL__85 BL_85 VSS VSS VDD VSS SIGN_MEMCCOG
XI8_0 BL_8 BL__8 WL WL VDD VSS SIGN_MEMCCEG
XI8_1 BL__8 BL_8 WL WL VDD VSS SIGN_MEMCCEG
XI90_0 BL_86 BL__86 VSS VSS VDD VSS SIGN_MEMCCEG
XI90_1 BL__86 BL_86 VSS VSS VDD VSS SIGN_MEMCCEG
XI91_0 BL_87 BL__87 VSS VSS VDD VSS SIGN_MEMCCOP
XI91_1 BL__87 BL_87 VSS VSS VDD VSS SIGN_MEMCCOP
XI92_0 BL_88 BL__88 VSS VSS VDD VSS SIGN_MEMCCEP
XI92_1 BL__88 BL_88 VSS VSS VDD VSS SIGN_MEMCCEP
XI93_0 BL_89 BL__89 VSS VSS VDD VSS SIGN_MEMCCOG
XI93_1 BL__89 BL_89 VSS VSS VDD VSS SIGN_MEMCCOG
XI94_0 BL_90 BL__90 VSS VSS VDD VSS SIGN_MEMCCEG
XI94_1 BL__90 BL_90 VSS VSS VDD VSS SIGN_MEMCCEG
XI95_0 BL_91 BL__91 VSS VSS VDD VSS SIGN_MEMCCOP
XI95_1 BL__91 BL_91 VSS VSS VDD VSS SIGN_MEMCCOP
XI96_0 BL_92 BL__92 VSS VSS VDD VSS SIGN_MEMCCEP
XI96_1 BL__92 BL_92 VSS VSS VDD VSS SIGN_MEMCCEP
XI97_0 BL_93 BL__93 VSS VSS VDD VSS SIGN_MEMCCOG
XI97_1 BL__93 BL_93 VSS VSS VDD VSS SIGN_MEMCCOG
XI98_0 NDL NDR VSS VDD VSS SIGN_MEMFLCCSTRAP
XI98_1 NDL NDR VSS VDD VSS SIGN_MEMFLCCSTRAP
XI99_0 BL_94 BL__94 VSS VSS VDD VSS SIGN_MEMCCEG
XI99_1 BL__94 BL_94 VSS VSS VDD VSS SIGN_MEMCCEG
XI9_0 BL_9 BL__9 WL WL VDD VSS SIGN_MEMCCOP
XI9_1 BL__9 BL_9 WL WL VDD VSS SIGN_MEMCCOP
.ENDS SIGN_MEMMROW_8_RIGHT
****
.SUBCKT SIGN_MEM Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5]
+  Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN WEN A[11] A[10] A[9] A[8] A[7] A[6] A[5]
+  A[4] A[3] A[2] A[1] A[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7]
+  D[6] D[5] D[4] D[3] D[2] D[1] D[0] VDD VSS
** SIGN_MEM: 414408 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP_2 GTP_2 GTP_2 VSS WE WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65
+  WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77
+  WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89
+  WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101
+  WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111
+  WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121
+  WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131
+  WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141
+  WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151
+  WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161
+  WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171
+  WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181
+  WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191
+  WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201
+  WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211
+  WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221
+  WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231
+  WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241
+  WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251
+  WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VDD VSS SIGN_MEMLEFT_CAP
XI1_0 A0 A0_ BLT_0 BLT_1 BLT_2 BLT_3 BLT_4 BLT_5 BLT_6 BLT_7 BLT_8 BLT_9
+  BLT_10 BLT_11 BLT_12 BLT_13 BLT_14 BLT_15 BLT_16 BLT_17 BLT_18 BLT_19
+  BLT_20 BLT_21 BLT_22 BLT_23 BLT_24 BLT_25 BLT_26 BLT_27 BLT_28 BLT_29
+  BLT_30 BLT_31 BLT_32 BLT_33 BLT_34 BLT_35 BLT_36 BLT_37 BLT_38 BLT_39
+  BLT_40 BLT_41 BLT_42 BLT_43 BLT_44 BLT_45 BLT_46 BLT_47 BLT_48 BLT_49
+  BLT_50 BLT_51 BLT_52 BLT_53 BLT_54 BLT_55 BLT_56 BLT_57 BLT_58 BLT_59
+  BLT_60 BLT_61 BLT_62 BLT_63 BLT_64 BLT_65 BLT_66 BLT_67 BLT_68 BLT_69
+  BLT_70 BLT_71 BLT_72 BLT_73 BLT_74 BLT_75 BLT_76 BLT_77 BLT_78 BLT_79
+  BLT_80 BLT_81 BLT_82 BLT_83 BLT_84 BLT_85 BLT_86 BLT_87 BLT_88 BLT_89
+  BLT_90 BLT_91 BLT_92 BLT_93 BLT_94 BLT_95 BLT_96 BLT_97 BLT_98 BLT_99
+  BLT_100 BLT_101 BLT_102 BLT_103 BLT_104 BLT_105 BLT_106 BLT_107 BLT_108
+  BLT_109 BLT_110 BLT_111 BLT_112 BLT_113 BLT_114 BLT_115 BLT_116 BLT_117
+  BLT_118 BLT_119 BLT_120 BLT_121 BLT_122 BLT_123 BLT_124 BLT_125 BLT_126
+  BLT_127 BLT__0 BLT__1 BLT__2 BLT__3 BLT__4 BLT__5 BLT__6 BLT__7 BLT__8
+  BLT__9 BLT__10 BLT__11 BLT__12 BLT__13 BLT__14 BLT__15 BLT__16 BLT__17
+  BLT__18 BLT__19 BLT__20 BLT__21 BLT__22 BLT__23 BLT__24 BLT__25 BLT__26
+  BLT__27 BLT__28 BLT__29 BLT__30 BLT__31 BLT__32 BLT__33 BLT__34 BLT__35
+  BLT__36 BLT__37 BLT__38 BLT__39 BLT__40 BLT__41 BLT__42 BLT__43 BLT__44
+  BLT__45 BLT__46 BLT__47 BLT__48 BLT__49 BLT__50 BLT__51 BLT__52 BLT__53
+  BLT__54 BLT__55 BLT__56 BLT__57 BLT__58 BLT__59 BLT__60 BLT__61 BLT__62
+  BLT__63 BLT__64 BLT__65 BLT__66 BLT__67 BLT__68 BLT__69 BLT__70 BLT__71
+  BLT__72 BLT__73 BLT__74 BLT__75 BLT__76 BLT__77 BLT__78 BLT__79 BLT__80
+  BLT__81 BLT__82 BLT__83 BLT__84 BLT__85 BLT__86 BLT__87 BLT__88 BLT__89
+  BLT__90 BLT__91 BLT__92 BLT__93 BLT__94 BLT__95 BLT__96 BLT__97 BLT__98
+  BLT__99 BLT__100 BLT__101 BLT__102 BLT__103 BLT__104 BLT__105 BLT__106
+  BLT__107 BLT__108 BLT__109 BLT__110 BLT__111 BLT__112 BLT__113 BLT__114
+  BLT__115 BLT__116 BLT__117 BLT__118 BLT__119 BLT__120 BLT__121 BLT__122
+  BLT__123 BLT__124 BLT__125 BLT__126 BLT__127 D[7] D[6] D[5] D[4] D[3] D[2]
+  D[1] D[0] GTP_2 GTP_2 GTP_2 VSS Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] DR
+  VSS DR_ VSS DW VSS DW_ VSS WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
+  SIGN_MEMWING_8_LEFT
XI1_5 BLT__64 BLT_64 BLT__65 BLT_65 BLT__0 BLT_1 BLT__2 BLT_3 BLT__4 BLT_5
+  BLT__6 BLT_7 BLT__8 BLT_9 BLT__10 BLT_11 BLT__12 BLT_13 BLT__14 BLT_15
+  BLT__16 BLT_17 BLT__18 BLT_19 BLT__20 BLT_21 BLT__22 BLT_23 BLT__24 BLT_25
+  BLT__26 BLT_27 BLT__28 BLT_29 BLT__30 BLT_31 BLT__32 BLT_33 BLT__34 BLT_35
+  BLT__36 BLT_37 BLT__38 BLT_39 BLT__40 BLT_41 BLT__42 BLT_43 BLT__44 BLT_45
+  BLT__46 BLT_47 BLT__48 BLT_49 BLT__50 BLT_51 BLT__52 BLT_53 BLT__54 BLT_55
+  BLT__56 BLT_57 BLT__58 BLT_59 BLT__60 BLT_61 BLT__62 BLT_63 BLT__66 BLT_67
+  BLT__68 BLT_69 BLT__70 BLT_71 BLT__72 BLT_73 BLT__74 BLT_75 BLT__76 BLT_77
+  BLT__78 BLT_79 BLT__80 BLT_81 BLT__82 BLT_83 BLT__84 BLT_85 BLT__86 BLT_87
+  BLT__88 BLT_89 BLT__90 BLT_91 BLT__92 BLT_93 BLT__94 BLT_95 BLT__96 BLT_97
+  BLT__98 BLT_99 BLT__100 BLT_101 BLT__102 BLT_103 BLT__104 BLT_105 BLT__106
+  BLT_107 BLT__108 BLT_109 BLT__110 BLT_111 BLT__112 BLT_113 BLT__114 BLT_115
+  BLT__116 BLT_117 BLT__118 BLT_119 BLT__120 BLT_121 BLT__122 BLT_123
+  BLT__124 BLT_125 BLT__126 BLT_127 BLT_0 BLT__1 BLT_2 BLT__3 BLT_4 BLT__5
+  BLT_6 BLT__7 BLT_8 BLT__9 BLT_10 BLT__11 BLT_12 BLT__13 BLT_14 BLT__15
+  BLT_16 BLT__17 BLT_18 BLT__19 BLT_20 BLT__21 BLT_22 BLT__23 BLT_24 BLT__25
+  BLT_26 BLT__27 BLT_28 BLT__29 BLT_30 BLT__31 BLT_32 BLT__33 BLT_34 BLT__35
+  BLT_36 BLT__37 BLT_38 BLT__39 BLT_40 BLT__41 BLT_42 BLT__43 BLT_44 BLT__45
+  BLT_46 BLT__47 BLT_48 BLT__49 BLT_50 BLT__51 BLT_52 BLT__53 BLT_54 BLT__55
+  BLT_56 BLT__57 BLT_58 BLT__59 BLT_60 BLT__61 BLT_62 BLT__63 BLT_66 BLT__67
+  BLT_68 BLT__69 BLT_70 BLT__71 BLT_72 BLT__73 BLT_74 BLT__75 BLT_76 BLT__77
+  BLT_78 BLT__79 BLT_80 BLT__81 BLT_82 BLT__83 BLT_84 BLT__85 BLT_86 BLT__87
+  BLT_88 BLT__89 BLT_90 BLT__91 BLT_92 BLT__93 BLT_94 BLT__95 BLT_96 BLT__97
+  BLT_98 BLT__99 BLT_100 BLT__101 BLT_102 BLT__103 BLT_104 BLT__105 BLT_106
+  BLT__107 BLT_108 BLT__109 BLT_110 BLT__111 BLT_112 BLT__113 BLT_114
+  BLT__115 BLT_116 BLT__117 BLT_118 BLT__119 BLT_120 BLT__121 BLT_122
+  BLT__123 BLT_124 BLT__125 BLT_126 BLT__127 MWLB VDD VSS SIGN_MEMMROW_8_LEFT
XI2_0 AGTPT AGTPT A0 A0_ GTP_2 MWLB VSS WE MWLB WL_0 WL_3 WL_4 WL_7 WL_8 WL_11
+  WL_12 WL_15 WL_16 WL_19 WL_20 WL_23 WL_24 WL_27 WL_28 WL_31 WL_32 WL_35
+  WL_36 WL_39 WL_40 WL_43 WL_44 WL_47 WL_48 WL_51 WL_52 WL_55 WL_56 WL_59
+  WL_60 WL_63 WL_64 WL_67 WL_68 WL_71 WL_72 WL_75 WL_76 WL_79 WL_80 WL_83
+  WL_84 WL_87 WL_88 WL_91 WL_92 WL_95 WL_96 WL_99 WL_100 WL_103 WL_104 WL_107
+  WL_108 WL_111 WL_112 WL_115 WL_116 WL_119 WL_120 WL_123 WL_124 WL_127
+  WL_128 WL_131 WL_132 WL_135 WL_136 WL_139 WL_140 WL_143 WL_144 WL_147
+  WL_148 WL_151 WL_152 WL_155 WL_156 WL_159 WL_160 WL_163 WL_164 WL_167
+  WL_168 WL_171 WL_172 WL_175 WL_176 WL_179 WL_180 WL_183 WL_184 WL_187
+  WL_188 WL_191 WL_192 WL_195 WL_196 WL_199 WL_200 WL_203 WL_204 WL_207
+  WL_208 WL_211 WL_212 WL_215 WL_216 WL_219 WL_220 WL_223 WL_224 WL_227
+  WL_228 WL_231 WL_232 WL_235 WL_236 WL_239 WL_240 WL_243 WL_244 WL_247
+  WL_248 WL_251 WL_252 WL_255 WL_1 WL_2 WL_5 WL_6 WL_9 WL_10 WL_13 WL_14
+  WL_17 WL_18 WL_21 WL_22 WL_25 WL_26 WL_29 WL_30 WL_33 WL_34 WL_37 WL_38
+  WL_41 WL_42 WL_45 WL_46 WL_49 WL_50 WL_53 WL_54 WL_57 WL_58 WL_61 WL_62
+  WL_65 WL_66 WL_69 WL_70 WL_73 WL_74 WL_77 WL_78 WL_81 WL_82 WL_85 WL_86
+  WL_89 WL_90 WL_93 WL_94 WL_97 WL_98 WL_101 WL_102 WL_105 WL_106 WL_109
+  WL_110 WL_113 WL_114 WL_117 WL_118 WL_121 WL_122 WL_125 WL_126 WL_129
+  WL_130 WL_133 WL_134 WL_137 WL_138 WL_141 WL_142 WL_145 WL_146 WL_149
+  WL_150 WL_153 WL_154 WL_157 WL_158 WL_161 WL_162 WL_165 WL_166 WL_169
+  WL_170 WL_173 WL_174 WL_177 WL_178 WL_181 WL_182 WL_185 WL_186 WL_189
+  WL_190 WL_193 WL_194 WL_197 WL_198 WL_201 WL_202 WL_205 WL_206 WL_209
+  WL_210 WL_213 WL_214 WL_217 WL_218 WL_221 WL_222 WL_225 WL_226 WL_229
+  WL_230 WL_233 WL_234 WL_237 WL_238 WL_241 WL_242 WL_245 WL_246 WL_249
+  WL_250 WL_253 WL_254 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD
+  VSS SIGN_MEMADDR_CAP
XI3_0 A[10] A[7] A[4] A[11] A[8] A[5] A[9] A[6] AGTPT AGTPT A0 A0_ VSS VSS WE
+  XP_0_0 XP_0_1 XP_0_2 XP_1_0 XP_1_1 XP_1_2 XP_2_0 XP_2_1 XP_2_2 XP_3_0
+  XP_3_1 XP_3_2 XP_4_0 XP_4_1 XP_5_0 XP_5_1 XP_6_0 XP_6_1 XP_7_0 XP_7_1 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMX_PRE_DECODE
XI3_3 GTP_2 MBL MBL_ MWLB MWLB WL_0 WL_3 WL_4 WL_7 WL_8 WL_11 WL_12 WL_15
+  WL_16 WL_19 WL_20 WL_23 WL_24 WL_27 WL_28 WL_31 WL_32 WL_35 WL_36 WL_39
+  WL_40 WL_43 WL_44 WL_47 WL_48 WL_51 WL_52 WL_55 WL_56 WL_59 WL_60 WL_63
+  WL_64 WL_67 WL_68 WL_71 WL_72 WL_75 WL_76 WL_79 WL_80 WL_83 WL_84 WL_87
+  WL_88 WL_91 WL_92 WL_95 WL_96 WL_99 WL_100 WL_103 WL_104 WL_107 WL_108
+  WL_111 WL_112 WL_115 WL_116 WL_119 WL_120 WL_123 WL_124 WL_127 WL_128
+  WL_131 WL_132 WL_135 WL_136 WL_139 WL_140 WL_143 WL_144 WL_147 WL_148
+  WL_151 WL_152 WL_155 WL_156 WL_159 WL_160 WL_163 WL_164 WL_167 WL_168
+  WL_171 WL_172 WL_175 WL_176 WL_179 WL_180 WL_183 WL_184 WL_187 WL_188
+  WL_191 WL_192 WL_195 WL_196 WL_199 WL_200 WL_203 WL_204 WL_207 WL_208
+  WL_211 WL_212 WL_215 WL_216 WL_219 WL_220 WL_223 WL_224 WL_227 WL_228
+  WL_231 WL_232 WL_235 WL_236 WL_239 WL_240 WL_243 WL_244 WL_247 WL_248
+  WL_251 WL_252 WL_255 WL_1 WL_2 WL_5 WL_6 WL_9 WL_10 WL_13 WL_14 WL_17 WL_18
+  WL_21 WL_22 WL_25 WL_26 WL_29 WL_30 WL_33 WL_34 WL_37 WL_38 WL_41 WL_42
+  WL_45 WL_46 WL_49 WL_50 WL_53 WL_54 WL_57 WL_58 WL_61 WL_62 WL_65 WL_66
+  WL_69 WL_70 WL_73 WL_74 WL_77 WL_78 WL_81 WL_82 WL_85 WL_86 WL_89 WL_90
+  WL_93 WL_94 WL_97 WL_98 WL_101 WL_102 WL_105 WL_106 WL_109 WL_110 WL_113
+  WL_114 WL_117 WL_118 WL_121 WL_122 WL_125 WL_126 WL_129 WL_130 WL_133
+  WL_134 WL_137 WL_138 WL_141 WL_142 WL_145 WL_146 WL_149 WL_150 WL_153
+  WL_154 WL_157 WL_158 WL_161 WL_162 WL_165 WL_166 WL_169 WL_170 WL_173
+  WL_174 WL_177 WL_178 WL_181 WL_182 WL_185 WL_186 WL_189 WL_190 WL_193
+  WL_194 WL_197 WL_198 WL_201 WL_202 WL_205 WL_206 WL_209 WL_210 WL_213
+  WL_214 WL_217 WL_218 WL_221 WL_222 WL_225 WL_226 WL_229 WL_230 WL_233
+  WL_234 WL_237 WL_238 WL_241 WL_242 WL_245 WL_246 WL_249 WL_250 WL_253
+  WL_254 XP_2_0 XP_0_0 XP_6_0 XP_4_0 XP_2_1 XP_0_1 XP_3_0 XP_1_0 XP_7_0
+  XP_5_0 XP_3_1 XP_1_1 XP_0_2 XP_1_2 XP_2_2 XP_3_2 XP_4_1 XP_5_1 XP_6_1
+  XP_7_1 VDD VSS SIGN_MEMWORD_ROWS
XI4_0 A[1] A[0] A[2] A[3] AGTPT A0 A0_ VSS CLK GSRCN GTPN VSS RST WE YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMY_DECODE
XI5_0 CEN CLK GSRCN GTP_2 GTPN MBL RST VSS WE WEN VDD VSS SIGN_MEMHBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTPN GTP_2 GTP_2 GTP_2 GTP_2 RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMCLK_DRVS
XI6_2 A0 A0_ MBL_ MBL CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMFLCIOX
XI6_4 MBL MBL_ WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71
+  WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83
+  WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95
+  WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106
+  WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116
+  WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126
+  WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136
+  WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146
+  WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156
+  WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166
+  WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176
+  WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186
+  WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196
+  WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206
+  WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216
+  WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226
+  WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236
+  WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246
+  WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 MWLB MWLB
+  VDD VSS SIGN_MEMMODEL_COL
XI7_0 A0 A0_ BLT_0_1065 BLT_1_1061 BLT_2_1057 BLT_3_1053 BLT_4_1049 BLT_5_1045
+  BLT_6_1041 BLT_7_1037 BLT_8_1033 BLT_9_1029 BLT_10_1025 BLT_11_1021
+  BLT_12_1017 BLT_13_1013 BLT_14_1009 BLT_15_1005 BLT_16_1001 BLT_17_997
+  BLT_18_993 BLT_19_989 BLT_20_985 BLT_21_981 BLT_22_977 BLT_23_973
+  BLT_24_969 BLT_25_965 BLT_26_961 BLT_27_957 BLT_28_953 BLT_29_949
+  BLT_30_945 BLT_31_941 BLT_32_937 BLT_33_933 BLT_34_929 BLT_35_925
+  BLT_36_921 BLT_37_917 BLT_38_913 BLT_39_909 BLT_40_905 BLT_41_901
+  BLT_42_897 BLT_43_893 BLT_44_889 BLT_45_885 BLT_46_881 BLT_47_877
+  BLT_48_873 BLT_49_869 BLT_50_865 BLT_51_861 BLT_52_857 BLT_53_853
+  BLT_54_849 BLT_55_845 BLT_56_841 BLT_57_837 BLT_58_833 BLT_59_829
+  BLT_60_825 BLT_61_821 BLT_62_817 BLT_63_813 BLT_64_809 BLT_65_805
+  BLT_66_801 BLT_67_797 BLT_68_793 BLT_69_789 BLT_70_785 BLT_71_781
+  BLT_72_777 BLT_73_773 BLT_74_769 BLT_75_765 BLT_76_761 BLT_77_757
+  BLT_78_753 BLT_79_749 BLT_80_745 BLT_81_741 BLT_82_737 BLT_83_733
+  BLT_84_729 BLT_85_725 BLT_86_721 BLT_87_717 BLT_88_713 BLT_89_709
+  BLT_90_705 BLT_91_701 BLT_92_697 BLT_93_693 BLT_94_689 BLT_95_685
+  BLT_96_681 BLT_97_677 BLT_98_673 BLT_99_669 BLT_100_665 BLT_101_661
+  BLT_102_657 BLT_103_653 BLT_104_649 BLT_105_645 BLT_106_641 BLT_107_637
+  BLT_108_633 BLT_109_629 BLT_110_625 BLT_111_621 BLT_112_617 BLT_113_613
+  BLT_114_609 BLT_115_605 BLT_116_601 BLT_117_597 BLT_118_593 BLT_119_589
+  BLT_120_585 BLT_121_581 BLT_122_577 BLT_123_573 BLT_124_569 BLT_125_565
+  BLT_126_561 BLT_127_557 BLT__0_1063 BLT__1_1059 BLT__2_1055 BLT__3_1051
+  BLT__4_1047 BLT__5_1043 BLT__6_1039 BLT__7_1035 BLT__8_1031 BLT__9_1027
+  BLT__10_1023 BLT__11_1019 BLT__12_1015 BLT__13_1011 BLT__14_1007
+  BLT__15_1003 BLT__16_999 BLT__17_995 BLT__18_991 BLT__19_987 BLT__20_983
+  BLT__21_979 BLT__22_975 BLT__23_971 BLT__24_967 BLT__25_963 BLT__26_959
+  BLT__27_955 BLT__28_951 BLT__29_947 BLT__30_943 BLT__31_939 BLT__32_935
+  BLT__33_931 BLT__34_927 BLT__35_923 BLT__36_919 BLT__37_915 BLT__38_911
+  BLT__39_907 BLT__40_903 BLT__41_899 BLT__42_895 BLT__43_891 BLT__44_887
+  BLT__45_883 BLT__46_879 BLT__47_875 BLT__48_871 BLT__49_867 BLT__50_863
+  BLT__51_859 BLT__52_855 BLT__53_851 BLT__54_847 BLT__55_843 BLT__56_839
+  BLT__57_835 BLT__58_831 BLT__59_827 BLT__60_823 BLT__61_819 BLT__62_815
+  BLT__63_811 BLT__64_807 BLT__65_803 BLT__66_799 BLT__67_795 BLT__68_791
+  BLT__69_787 BLT__70_783 BLT__71_779 BLT__72_775 BLT__73_771 BLT__74_767
+  BLT__75_763 BLT__76_759 BLT__77_755 BLT__78_751 BLT__79_747 BLT__80_743
+  BLT__81_739 BLT__82_735 BLT__83_731 BLT__84_727 BLT__85_723 BLT__86_719
+  BLT__87_715 BLT__88_711 BLT__89_707 BLT__90_703 BLT__91_699 BLT__92_695
+  BLT__93_691 BLT__94_687 BLT__95_683 BLT__96_679 BLT__97_675 BLT__98_671
+  BLT__99_667 BLT__100_663 BLT__101_659 BLT__102_655 BLT__103_651
+  BLT__104_647 BLT__105_643 BLT__106_639 BLT__107_635 BLT__108_631
+  BLT__109_627 BLT__110_623 BLT__111_619 BLT__112_615 BLT__113_611
+  BLT__114_607 BLT__115_603 BLT__116_599 BLT__117_595 BLT__118_591
+  BLT__119_587 BLT__120_583 BLT__121_579 BLT__122_575 BLT__123_571
+  BLT__124_567 BLT__125_563 BLT__126_559 BLT__127_555 D[8] D[9] D[10] D[11]
+  D[12] D[13] D[14] D[15] GTP_2 GTP_2 GTP_2 VSS Q[8] Q[9] Q[10] Q[11] Q[12]
+  Q[13] Q[14] Q[15] VSS STUBDR_1 VSS STUBDR__1 VSS STUBDW_1 VSS STUBDW__1 WE
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68 WL_69 WL_70 WL_71 WL_72 WL_73
+  WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80 WL_81 WL_82 WL_83 WL_84 WL_85
+  WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92 WL_93 WL_94 WL_95 WL_96 WL_97
+  WL_98 WL_99 WL_100 WL_101 WL_102 WL_103 WL_104 WL_105 WL_106 WL_107 WL_108
+  WL_109 WL_110 WL_111 WL_112 WL_113 WL_114 WL_115 WL_116 WL_117 WL_118
+  WL_119 WL_120 WL_121 WL_122 WL_123 WL_124 WL_125 WL_126 WL_127 WL_128
+  WL_129 WL_130 WL_131 WL_132 WL_133 WL_134 WL_135 WL_136 WL_137 WL_138
+  WL_139 WL_140 WL_141 WL_142 WL_143 WL_144 WL_145 WL_146 WL_147 WL_148
+  WL_149 WL_150 WL_151 WL_152 WL_153 WL_154 WL_155 WL_156 WL_157 WL_158
+  WL_159 WL_160 WL_161 WL_162 WL_163 WL_164 WL_165 WL_166 WL_167 WL_168
+  WL_169 WL_170 WL_171 WL_172 WL_173 WL_174 WL_175 WL_176 WL_177 WL_178
+  WL_179 WL_180 WL_181 WL_182 WL_183 WL_184 WL_185 WL_186 WL_187 WL_188
+  WL_189 WL_190 WL_191 WL_192 WL_193 WL_194 WL_195 WL_196 WL_197 WL_198
+  WL_199 WL_200 WL_201 WL_202 WL_203 WL_204 WL_205 WL_206 WL_207 WL_208
+  WL_209 WL_210 WL_211 WL_212 WL_213 WL_214 WL_215 WL_216 WL_217 WL_218
+  WL_219 WL_220 WL_221 WL_222 WL_223 WL_224 WL_225 WL_226 WL_227 WL_228
+  WL_229 WL_230 WL_231 WL_232 WL_233 WL_234 WL_235 WL_236 WL_237 WL_238
+  WL_239 WL_240 WL_241 WL_242 WL_243 WL_244 WL_245 WL_246 WL_247 WL_248
+  WL_249 WL_250 WL_251 WL_252 WL_253 WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS SIGN_MEMWING_8_RIGHT
XI7_5 BLT_64_809 BLT__64_807 BLT_65_805 BLT__65_803 BLT_0_1065 BLT__1_1059
+  BLT_2_1057 BLT__3_1051 BLT_4_1049 BLT__5_1043 BLT_6_1041 BLT__7_1035
+  BLT_8_1033 BLT__9_1027 BLT_10_1025 BLT__11_1019 BLT_12_1017 BLT__13_1011
+  BLT_14_1009 BLT__15_1003 BLT_16_1001 BLT__17_995 BLT_18_993 BLT__19_987
+  BLT_20_985 BLT__21_979 BLT_22_977 BLT__23_971 BLT_24_969 BLT__25_963
+  BLT_26_961 BLT__27_955 BLT_28_953 BLT__29_947 BLT_30_945 BLT__31_939
+  BLT_32_937 BLT__33_931 BLT_34_929 BLT__35_923 BLT_36_921 BLT__37_915
+  BLT_38_913 BLT__39_907 BLT_40_905 BLT__41_899 BLT_42_897 BLT__43_891
+  BLT_44_889 BLT__45_883 BLT_46_881 BLT__47_875 BLT_48_873 BLT__49_867
+  BLT_50_865 BLT__51_859 BLT_52_857 BLT__53_851 BLT_54_849 BLT__55_843
+  BLT_56_841 BLT__57_835 BLT_58_833 BLT__59_827 BLT_60_825 BLT__61_819
+  BLT_62_817 BLT__63_811 BLT_66_801 BLT__67_795 BLT_68_793 BLT__69_787
+  BLT_70_785 BLT__71_779 BLT_72_777 BLT__73_771 BLT_74_769 BLT__75_763
+  BLT_76_761 BLT__77_755 BLT_78_753 BLT__79_747 BLT_80_745 BLT__81_739
+  BLT_82_737 BLT__83_731 BLT_84_729 BLT__85_723 BLT_86_721 BLT__87_715
+  BLT_88_713 BLT__89_707 BLT_90_705 BLT__91_699 BLT_92_697 BLT__93_691
+  BLT_94_689 BLT__95_683 BLT_96_681 BLT__97_675 BLT_98_673 BLT__99_667
+  BLT_100_665 BLT__101_659 BLT_102_657 BLT__103_651 BLT_104_649 BLT__105_643
+  BLT_106_641 BLT__107_635 BLT_108_633 BLT__109_627 BLT_110_625 BLT__111_619
+  BLT_112_617 BLT__113_611 BLT_114_609 BLT__115_603 BLT_116_601 BLT__117_595
+  BLT_118_593 BLT__119_587 BLT_120_585 BLT__121_579 BLT_122_577 BLT__123_571
+  BLT_124_569 BLT__125_563 BLT_126_561 BLT__127_555 BLT__0_1063 BLT_1_1061
+  BLT__2_1055 BLT_3_1053 BLT__4_1047 BLT_5_1045 BLT__6_1039 BLT_7_1037
+  BLT__8_1031 BLT_9_1029 BLT__10_1023 BLT_11_1021 BLT__12_1015 BLT_13_1013
+  BLT__14_1007 BLT_15_1005 BLT__16_999 BLT_17_997 BLT__18_991 BLT_19_989
+  BLT__20_983 BLT_21_981 BLT__22_975 BLT_23_973 BLT__24_967 BLT_25_965
+  BLT__26_959 BLT_27_957 BLT__28_951 BLT_29_949 BLT__30_943 BLT_31_941
+  BLT__32_935 BLT_33_933 BLT__34_927 BLT_35_925 BLT__36_919 BLT_37_917
+  BLT__38_911 BLT_39_909 BLT__40_903 BLT_41_901 BLT__42_895 BLT_43_893
+  BLT__44_887 BLT_45_885 BLT__46_879 BLT_47_877 BLT__48_871 BLT_49_869
+  BLT__50_863 BLT_51_861 BLT__52_855 BLT_53_853 BLT__54_847 BLT_55_845
+  BLT__56_839 BLT_57_837 BLT__58_831 BLT_59_829 BLT__60_823 BLT_61_821
+  BLT__62_815 BLT_63_813 BLT__66_799 BLT_67_797 BLT__68_791 BLT_69_789
+  BLT__70_783 BLT_71_781 BLT__72_775 BLT_73_773 BLT__74_767 BLT_75_765
+  BLT__76_759 BLT_77_757 BLT__78_751 BLT_79_749 BLT__80_743 BLT_81_741
+  BLT__82_735 BLT_83_733 BLT__84_727 BLT_85_725 BLT__86_719 BLT_87_717
+  BLT__88_711 BLT_89_709 BLT__90_703 BLT_91_701 BLT__92_695 BLT_93_693
+  BLT__94_687 BLT_95_685 BLT__96_679 BLT_97_677 BLT__98_671 BLT_99_669
+  BLT__100_663 BLT_101_661 BLT__102_655 BLT_103_653 BLT__104_647 BLT_105_645
+  BLT__106_639 BLT_107_637 BLT__108_631 BLT_109_629 BLT__110_623 BLT_111_621
+  BLT__112_615 BLT_113_613 BLT__114_607 BLT_115_605 BLT__116_599 BLT_117_597
+  BLT__118_591 BLT_119_589 BLT__120_583 BLT_121_581 BLT__122_575 BLT_123_573
+  BLT__124_567 BLT_125_565 BLT__126_559 BLT_127_557 MWLB VDD VSS
+  SIGN_MEMMROW_8_RIGHT
XI8_0 A0 A0_ GTP_2 GTP_2 GTP_2 VSS WE WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 WL_66 WL_67 WL_68
+  WL_69 WL_70 WL_71 WL_72 WL_73 WL_74 WL_75 WL_76 WL_77 WL_78 WL_79 WL_80
+  WL_81 WL_82 WL_83 WL_84 WL_85 WL_86 WL_87 WL_88 WL_89 WL_90 WL_91 WL_92
+  WL_93 WL_94 WL_95 WL_96 WL_97 WL_98 WL_99 WL_100 WL_101 WL_102 WL_103
+  WL_104 WL_105 WL_106 WL_107 WL_108 WL_109 WL_110 WL_111 WL_112 WL_113
+  WL_114 WL_115 WL_116 WL_117 WL_118 WL_119 WL_120 WL_121 WL_122 WL_123
+  WL_124 WL_125 WL_126 WL_127 WL_128 WL_129 WL_130 WL_131 WL_132 WL_133
+  WL_134 WL_135 WL_136 WL_137 WL_138 WL_139 WL_140 WL_141 WL_142 WL_143
+  WL_144 WL_145 WL_146 WL_147 WL_148 WL_149 WL_150 WL_151 WL_152 WL_153
+  WL_154 WL_155 WL_156 WL_157 WL_158 WL_159 WL_160 WL_161 WL_162 WL_163
+  WL_164 WL_165 WL_166 WL_167 WL_168 WL_169 WL_170 WL_171 WL_172 WL_173
+  WL_174 WL_175 WL_176 WL_177 WL_178 WL_179 WL_180 WL_181 WL_182 WL_183
+  WL_184 WL_185 WL_186 WL_187 WL_188 WL_189 WL_190 WL_191 WL_192 WL_193
+  WL_194 WL_195 WL_196 WL_197 WL_198 WL_199 WL_200 WL_201 WL_202 WL_203
+  WL_204 WL_205 WL_206 WL_207 WL_208 WL_209 WL_210 WL_211 WL_212 WL_213
+  WL_214 WL_215 WL_216 WL_217 WL_218 WL_219 WL_220 WL_221 WL_222 WL_223
+  WL_224 WL_225 WL_226 WL_227 WL_228 WL_229 WL_230 WL_231 WL_232 WL_233
+  WL_234 WL_235 WL_236 WL_237 WL_238 WL_239 WL_240 WL_241 WL_242 WL_243
+  WL_244 WL_245 WL_246 WL_247 WL_248 WL_249 WL_250 WL_251 WL_252 WL_253
+  WL_254 WL_255 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VDD VSS
+  SIGN_MEMRIGHT_CAP
.ENDS SIGN_MEM
